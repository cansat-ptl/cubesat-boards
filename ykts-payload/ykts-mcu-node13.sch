File: ykts-payload/ykts-mcu-node13.sch (KiCad schematic (older format))
At the start: 12 parts, among them J22 AVR-ISP-6, SW14 ADG802BRT, U27 ATmega328PB-MU, Y16 8 MHz

Commit message: Revision B0
Added second supervisor, mega2560 -> mega128a
Parts:
- renumbered C80 to C91, C81 to C92, C82 to C93, C83 to C94, D21 to D23, J22 to J26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
Changed lines of the file:
@@
 Sheet 16 18
 Title "YktSat Payload Module"
-Date "2021-10-03"
-Rev "A3"
+Date "2021-10-22"
+Rev "B0"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/6572958C/65833EDE" Ref="U?"  Part="1"
 AR Path="/6174477C/6577909A/65833EDE" Ref="U?"  Part="1"
-AR Path="/6174477C/657790A4/65833EDE" Ref="U27"  Part="1"
-F 0 "U27" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/657790A4/65833EDE" Ref="U25"  Part="1"
+F 0 "U25" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/6572958C/65833DBF" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DBF" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A4/65833DBF" Ref="C80"  Part="1"
-F 0 "C80" H 4442 2646 50  0000 L CNN
+AR Path="/6174477C/657790A4/65833DBF" Ref="C91"  Part="1"
+F 0 "C91" H 4442 2646 50  0000 L CNN
 F 1 "1uF" H 4442 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4350 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ED2" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833ED2" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A4/65833ED2" Ref="C81"  Part="1"
-F 0 "C81" H 4792 2646 50  0000 L CNN
+AR Path="/6174477C/657790A4/65833ED2" Ref="C92"  Part="1"
+F 0 "C92" H 4792 2646 50  0000 L CNN
 F 1 "100nF" H 4792 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4700 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DEA" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DEA" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833DEA" Ref="#PWR0221"  Part="1"
-F 0 "#PWR0221" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833DEA" Ref="#PWR0235"  Part="1"
+F 0 "#PWR0235" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DFC" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DFC" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A4/65833DFC" Ref="C83"  Part="1"
-F 0 "C83" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A4/65833DFC" Ref="C94"  Part="1"
+F 0 "C94" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EA1" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833EA1" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A4/65833EA1" Ref="C82"  Part="1"
-F 0 "C82" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A4/65833EA1" Ref="C93"  Part="1"
+F 0 "C93" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EAF" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EAF" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833EAF" Ref="#PWR0229"  Part="1"
-F 0 "#PWR0229" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833EAF" Ref="#PWR0243"  Part="1"
+F 0 "#PWR0243" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/6391666E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/6391666E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/6391666E" Ref="#PWR0225"  Part="1"
-F 0 "#PWR0225" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/657790A4/6391666E" Ref="#PWR0239"  Part="1"
+F 0 "#PWR0239" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ECD" Ref="Y?"  Part="1"
 AR Path="/6174477C/6577909A/65833ECD" Ref="Y?"  Part="1"
-AR Path="/6174477C/657790A4/65833ECD" Ref="Y16"  Part="1"
-F 0 "Y16" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/657790A4/65833ECD" Ref="Y18"  Part="1"
+F 0 "Y18" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E0A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E0A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833E0A" Ref="#PWR0226"  Part="1"
-F 0 "#PWR0226" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833E0A" Ref="#PWR0240"  Part="1"
+F 0 "#PWR0240" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E19" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E19" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833E19" Ref="#PWR0227"  Part="1"
-F 0 "#PWR0227" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833E19" Ref="#PWR0241"  Part="1"
+F 0 "#PWR0241" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DD4" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833DD4" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A4/65833DD4" Ref="R112"  Part="1"
-F 0 "R112" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/657790A4/65833DD4" Ref="R90"  Part="1"
+F 0 "R90" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E28" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E28" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833E28" Ref="#PWR0220"  Part="1"
-F 0 "#PWR0220" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833E28" Ref="#PWR0234"  Part="1"
+F 0 "#PWR0234" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E32" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E32" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833E32" Ref="#PWR0223"  Part="1"
-F 0 "#PWR0223" H 4700 2600 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833E32" Ref="#PWR0237"  Part="1"
+F 0 "#PWR0237" H 4700 2600 50  0001 C CNN
 F 1 "GND" H 4705 2677 50  0000 C CNN
 F 2 "" H 4700 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E40" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E40" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A4/65833E40" Ref="R113"  Part="1"
-F 0 "R113" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/657790A4/65833E40" Ref="R91"  Part="1"
+F 0 "R91" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E4F" Ref="J?"  Part="1"
 AR Path="/6174477C/6577909A/65833E4F" Ref="J?"  Part="1"
-AR Path="/6174477C/657790A4/65833E4F" Ref="J22"  Part="1"
-F 0 "J22" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/657790A4/65833E4F" Ref="J26"  Part="1"
+F 0 "J26" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E60" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E60" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833E60" Ref="#PWR0222"  Part="1"
-F 0 "#PWR0222" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833E60" Ref="#PWR0236"  Part="1"
+F 0 "#PWR0236" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E6E" Ref="D?"  Part="1"
 AR Path="/6174477C/6577909A/65833E6E" Ref="D?"  Part="1"
-AR Path="/6174477C/657790A4/65833E6E" Ref="D21"  Part="1"
-F 0 "D21" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/657790A4/65833E6E" Ref="D23"  Part="1"
+F 0 "D23" V 8439 2682 50  0000 R CNN
 F 1 "NODE13_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/6386EF44" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/6386EF44" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A4/6386EF44" Ref="R114"  Part="1"
-F 0 "R114" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/657790A4/6386EF44" Ref="R92"  Part="1"
+F 0 "R92" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EF8" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EF8" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833EF8" Ref="#PWR0228"  Part="1"
-F 0 "#PWR0228" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833EF8" Ref="#PWR0242"  Part="1"
+F 0 "#PWR0242" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DC6" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DC6" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A4/65833DC6" Ref="#PWR0224"  Part="1"
-F 0 "#PWR0224" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/657790A4/65833DC6" Ref="#PWR0238"  Part="1"
+F 0 "#PWR0238" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
