File: ykts-payload/ykts-mcu-node13.sch (KiCad schematic (older format))
At the start: 12 parts, among them J18 AVR-ISP-6, SW13 ADG802BRT, U26 ATmega328PB-MU, Y15 8 MHz

Commit message: Fixed annotations & sheet ordering
Parts:
- renumbered C76 to C80, C77 to C81, C78 to C82, C79 to C83, D18 to D22, J18 to J21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
Changed lines of the file:
@@
 Sheet 15 18
 Title "YktSat Payload Module"
-Date "2021-09-30"
-Rev "A0"
+Date "2021-10-02"
+Rev "A1"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/638385B8/6386F033" Ref="U?"  Part="1"
 AR Path="/6174477C/638385BA/6386F033" Ref="U?"  Part="1"
-AR Path="/6174477C/638DF125/6386F033" Ref="U26"  Part="1"
-F 0 "U26" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/638DF125/6386F033" Ref="U27"  Part="1"
+F 0 "U27" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/638385B8/63916B7B" Ref="SW?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7B" Ref="SW?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7B" Ref="SW13"  Part="1"
-F 0 "SW13" H 3500 2631 50  0000 C CNN
+AR Path="/6174477C/638DF125/63916B7B" Ref="SW14"  Part="1"
+F 0 "SW14" H 3500 2631 50  0000 C CNN
 F 1 "ADG802BRT" H 3500 2540 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:SOT-23-6" H 3500 2500 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F13C" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BA/6386F13C" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF125/6386F13C" Ref="C76"  Part="1"
-F 0 "C76" H 4292 2646 50  0000 L CNN
+AR Path="/6174477C/638DF125/6386F13C" Ref="C80"  Part="1"
+F 0 "C80" H 4292 2646 50  0000 L CNN
 F 1 "1uF" H 4292 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4200 2600 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F13D" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BA/6386F13D" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF125/6386F13D" Ref="C77"  Part="1"
-F 0 "C77" H 4642 2646 50  0000 L CNN
+AR Path="/6174477C/638DF125/6386F13D" Ref="C81"  Part="1"
+F 0 "C81" H 4642 2646 50  0000 L CNN
 F 1 "100nF" H 4642 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4550 2600 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B88" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B88" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B88" Ref="#PWR0277"  Part="1"
-F 0 "#PWR0277" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B88" Ref="#PWR0219"  Part="1"
+F 0 "#PWR0219" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B89" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BA/63916B89" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF125/63916B89" Ref="C79"  Part="1"
-F 0 "C79" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF125/63916B89" Ref="C83"  Part="1"
+F 0 "C83" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B82" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BA/63916B82" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF125/63916B82" Ref="C78"  Part="1"
-F 0 "C78" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF125/63916B82" Ref="C82"  Part="1"
+F 0 "C82" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F145" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F145" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F145" Ref="#PWR0278"  Part="1"
-F 0 "#PWR0278" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F145" Ref="#PWR0227"  Part="1"
+F 0 "#PWR0227" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B8B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B8B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B8B" Ref="#PWR0279"  Part="1"
-F 0 "#PWR0279" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B8B" Ref="#PWR0223"  Part="1"
+F 0 "#PWR0223" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B85" Ref="Y?"  Part="1"
 AR Path="/6174477C/638385BA/63916B85" Ref="Y?"  Part="1"
-AR Path="/6174477C/638DF125/63916B85" Ref="Y15"  Part="1"
-F 0 "Y15" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/638DF125/63916B85" Ref="Y16"  Part="1"
+F 0 "Y16" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/638383B9" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/638383B9" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/638383B9" Ref="#PWR0280"  Part="1"
-F 0 "#PWR0280" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF125/638383B9" Ref="#PWR0224"  Part="1"
+F 0 "#PWR0224" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F03E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F03E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F03E" Ref="#PWR0281"  Part="1"
-F 0 "#PWR0281" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F03E" Ref="#PWR0225"  Part="1"
+F 0 "#PWR0225" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B83" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/63916B83" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/63916B83" Ref="R95"  Part="1"
-F 0 "R95" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF125/63916B83" Ref="R108"  Part="1"
+F 0 "R108" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7D" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7D" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7D" Ref="#PWR0282"  Part="1"
-F 0 "#PWR0282" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7D" Ref="#PWR0218"  Part="1"
+F 0 "#PWR0218" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7E" Ref="#PWR0283"  Part="1"
-F 0 "#PWR0283" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7E" Ref="#PWR0221"  Part="1"
+F 0 "#PWR0221" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B78" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/63916B78" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/63916B78" Ref="R96"  Part="1"
-F 0 "R96" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF125/63916B78" Ref="R109"  Part="1"
+F 0 "R109" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6378E8AB" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BA/6378E8AB" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF125/6378E8AB" Ref="J18"  Part="1"
-F 0 "J18" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF125/6378E8AB" Ref="J21"  Part="1"
+F 0 "J21" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7A" Ref="#PWR0284"  Part="1"
-F 0 "#PWR0284" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7A" Ref="#PWR0220"  Part="1"
+F 0 "#PWR0220" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F046" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BA/6386F046" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF125/6386F046" Ref="D18"  Part="1"
-F 0 "D18" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF125/6386F046" Ref="D22"  Part="1"
+F 0 "D22" V 8439 2682 50  0000 R CNN
 F 1 "NODE13_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F14A" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/6386F14A" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/6386F14A" Ref="R97"  Part="1"
-F 0 "R97" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF125/6386F14A" Ref="R110"  Part="1"
+F 0 "R110" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F14B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F14B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F14B" Ref="#PWR0285"  Part="1"
-F 0 "#PWR0285" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F14B" Ref="#PWR0226"  Part="1"
+F 0 "#PWR0226" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F040" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F040" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F040" Ref="#PWR0286"  Part="1"
-F 0 "#PWR0286" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F040" Ref="#PWR0222"  Part="1"
+F 0 "#PWR0222" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
