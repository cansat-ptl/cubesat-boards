File: ykts-payload/ykts-mcu-node13.sch (KiCad schematic (older format))
At the start: 12 parts, among them J21 AVR-ISP-6, SW14 ADG802BRT, U27 ATmega328PB-MU, Y16 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D22 to D21, J21 to J22, R108 to R112, R109 to R113, R110 to R114
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 15 18
+Sheet 16 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/638385B8/63916B88" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B88" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B88" Ref="#PWR0219"  Part="1"
-F 0 "#PWR0219" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B88" Ref="#PWR0221"  Part="1"
+F 0 "#PWR0221" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F145" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F145" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F145" Ref="#PWR0227"  Part="1"
-F 0 "#PWR0227" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F145" Ref="#PWR0229"  Part="1"
+F 0 "#PWR0229" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B8B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B8B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B8B" Ref="#PWR0223"  Part="1"
-F 0 "#PWR0223" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B8B" Ref="#PWR0225"  Part="1"
+F 0 "#PWR0225" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/638383B9" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/638383B9" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/638383B9" Ref="#PWR0224"  Part="1"
-F 0 "#PWR0224" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF125/638383B9" Ref="#PWR0226"  Part="1"
+F 0 "#PWR0226" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F03E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F03E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F03E" Ref="#PWR0225"  Part="1"
-F 0 "#PWR0225" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F03E" Ref="#PWR0227"  Part="1"
+F 0 "#PWR0227" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B83" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/63916B83" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/63916B83" Ref="R108"  Part="1"
-F 0 "R108" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF125/63916B83" Ref="R112"  Part="1"
+F 0 "R112" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7D" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7D" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7D" Ref="#PWR0218"  Part="1"
-F 0 "#PWR0218" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7D" Ref="#PWR0220"  Part="1"
+F 0 "#PWR0220" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7E" Ref="#PWR0221"  Part="1"
-F 0 "#PWR0221" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7E" Ref="#PWR0223"  Part="1"
+F 0 "#PWR0223" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B78" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/63916B78" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/63916B78" Ref="R109"  Part="1"
-F 0 "R109" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF125/63916B78" Ref="R113"  Part="1"
+F 0 "R113" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6378E8AB" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BA/6378E8AB" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF125/6378E8AB" Ref="J21"  Part="1"
-F 0 "J21" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF125/6378E8AB" Ref="J22"  Part="1"
+F 0 "J22" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916B7A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916B7A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/63916B7A" Ref="#PWR0220"  Part="1"
-F 0 "#PWR0220" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF125/63916B7A" Ref="#PWR0222"  Part="1"
+F 0 "#PWR0222" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F046" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BA/6386F046" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF125/6386F046" Ref="D22"  Part="1"
-F 0 "D22" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF125/6386F046" Ref="D21"  Part="1"
+F 0 "D21" V 8439 2682 50  0000 R CNN
 F 1 "NODE13_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F14A" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/6386F14A" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF125/6386F14A" Ref="R110"  Part="1"
-F 0 "R110" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF125/6386F14A" Ref="R114"  Part="1"
+F 0 "R114" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F14B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F14B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F14B" Ref="#PWR0226"  Part="1"
-F 0 "#PWR0226" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F14B" Ref="#PWR0228"  Part="1"
+F 0 "#PWR0228" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F040" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F040" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF125/6386F040" Ref="#PWR0222"  Part="1"
-F 0 "#PWR0222" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF125/6386F040" Ref="#PWR0224"  Part="1"
+F 0 "#PWR0224" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C80.1, C81.1, D21.2 (A), R112.2, U27.18 (AVCC), U27.20 (AREF), U27.4 (VCC)
- net at SW14.1 (D): now also C80.1, C81.1, D21.2 (A), R112.2, U27.18 (AVCC), U27.20 (AREF), U27.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J22: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J22" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
