File: ykts-payload/ykts-mcu-node12.sch (KiCad schematic (older format))
At the start: 12 parts, among them J20 AVR-ISP-6, SW13 ADG802BRT, U26 ATmega328PB-MU, Y15 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D21 to D20, J20 to J21, R105 to R109, R106 to R110, R107 to R111
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 14 18
+Sheet 15 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/63801AEE/6386EF33" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/6386EF33" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/6386EF33" Ref="#PWR0209"  Part="1"
-F 0 "#PWR0209" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF123/6386EF33" Ref="#PWR0211"  Part="1"
+F 0 "#PWR0211" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/6386EF3B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/6386EF3B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/6386EF3B" Ref="#PWR0217"  Part="1"
-F 0 "#PWR0217" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF123/6386EF3B" Ref="#PWR0219"  Part="1"
+F 0 "#PWR0219" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/6386EF3C" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/6386EF3C" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/6386EF3C" Ref="#PWR0213"  Part="1"
-F 0 "#PWR0213" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF123/6386EF3C" Ref="#PWR0215"  Part="1"
+F 0 "#PWR0215" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/63760B1F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/63760B1F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/63760B1F" Ref="#PWR0214"  Part="1"
-F 0 "#PWR0214" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF123/63760B1F" Ref="#PWR0216"  Part="1"
+F 0 "#PWR0216" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/63760B25" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/63760B25" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/63760B25" Ref="#PWR0215"  Part="1"
-F 0 "#PWR0215" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF123/63760B25" Ref="#PWR0217"  Part="1"
+F 0 "#PWR0217" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/63916A8A" Ref="R?"  Part="1"
 AR Path="/6174477C/638385B6/63916A8A" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF123/63916A8A" Ref="R105"  Part="1"
-F 0 "R105" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF123/63916A8A" Ref="R109"  Part="1"
+F 0 "R109" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/6376D72E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/6376D72E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/6376D72E" Ref="#PWR0208"  Part="1"
-F 0 "#PWR0208" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF123/6376D72E" Ref="#PWR0210"  Part="1"
+F 0 "#PWR0210" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/63916A7A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/63916A7A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/63916A7A" Ref="#PWR0211"  Part="1"
-F 0 "#PWR0211" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF123/63916A7A" Ref="#PWR0213"  Part="1"
+F 0 "#PWR0213" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/638383BE" Ref="R?"  Part="1"
 AR Path="/6174477C/638385B6/638383BE" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF123/638383BE" Ref="R106"  Part="1"
-F 0 "R106" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF123/638383BE" Ref="R110"  Part="1"
+F 0 "R110" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/638383BF" Ref="J?"  Part="1"
 AR Path="/6174477C/638385B6/638383BF" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF123/638383BF" Ref="J20"  Part="1"
-F 0 "J20" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF123/638383BF" Ref="J21"  Part="1"
+F 0 "J21" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/638383C0" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/638383C0" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/638383C0" Ref="#PWR0210"  Part="1"
-F 0 "#PWR0210" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF123/638383C0" Ref="#PWR0212"  Part="1"
+F 0 "#PWR0212" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/638383C1" Ref="D?"  Part="1"
 AR Path="/6174477C/638385B6/638383C1" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF123/638383C1" Ref="D21"  Part="1"
-F 0 "D21" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF123/638383C1" Ref="D20"  Part="1"
+F 0 "D20" V 8439 2682 50  0000 R CNN
 F 1 "NODE12_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/638383C2" Ref="R?"  Part="1"
 AR Path="/6174477C/638385B6/638383C2" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF123/638383C2" Ref="R107"  Part="1"
-F 0 "R107" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF123/638383C2" Ref="R111"  Part="1"
+F 0 "R111" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/63916A80" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/63916A80" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/63916A80" Ref="#PWR0216"  Part="1"
-F 0 "#PWR0216" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF123/63916A80" Ref="#PWR0218"  Part="1"
+F 0 "#PWR0218" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/63801AEE/6386EF38" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385B6/6386EF38" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF123/6386EF38" Ref="#PWR0212"  Part="1"
-F 0 "#PWR0212" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF123/6386EF38" Ref="#PWR0214"  Part="1"
+F 0 "#PWR0214" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C76.1, C77.1, D20.2 (A), R109.2, U26.18 (AVCC), U26.20 (AREF), U26.4 (VCC)
- net at SW13.1 (D): now also C76.1, C77.1, D20.2 (A), R109.2, U26.18 (AVCC), U26.20 (AREF), U26.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J21: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J21" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
