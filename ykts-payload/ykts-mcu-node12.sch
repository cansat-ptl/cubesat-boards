File: ykts-payload/ykts-mcu-node12.sch (KiCad schematic (older format))
At the start: 12 parts, among them J21 AVR-ISP-6, SW13 ADG802BRT, U26 ATmega328PB-MU, Y15 8 MHz

Commit message: Revision B0
Added second supervisor, mega2560 -> mega128a
Parts:
- renumbered C76 to C87, C77 to C88, C78 to C89, C79 to C90, D20 to D22, J21 to J25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
Changed lines of the file:
@@
 Sheet 15 18
 Title "YktSat Payload Module"
-Date "2021-10-03"
-Rev "A3"
+Date "2021-10-22"
+Rev "B0"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/6572958C/65833EDF" Ref="U?"  Part="1"
 AR Path="/6174477C/6577909A/65833EDF" Ref="U?"  Part="1"
-AR Path="/6174477C/657790A2/65833EDF" Ref="U26"  Part="1"
-F 0 "U26" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/657790A2/65833EDF" Ref="U24"  Part="1"
+F 0 "U24" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/6572958C/65833DBA" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DBA" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A2/65833DBA" Ref="C76"  Part="1"
-F 0 "C76" H 4442 2646 50  0000 L CNN
+AR Path="/6174477C/657790A2/65833DBA" Ref="C87"  Part="1"
+F 0 "C87" H 4442 2646 50  0000 L CNN
 F 1 "1uF" H 4442 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4350 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ED5" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833ED5" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A2/65833ED5" Ref="C77"  Part="1"
-F 0 "C77" H 4792 2646 50  0000 L CNN
+AR Path="/6174477C/657790A2/65833ED5" Ref="C88"  Part="1"
+F 0 "C88" H 4792 2646 50  0000 L CNN
 F 1 "100nF" H 4792 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4700 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DED" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DED" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833DED" Ref="#PWR0211"  Part="1"
-F 0 "#PWR0211" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833DED" Ref="#PWR0225"  Part="1"
+F 0 "#PWR0225" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DF7" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DF7" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A2/65833DF7" Ref="C79"  Part="1"
-F 0 "C79" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A2/65833DF7" Ref="C90"  Part="1"
+F 0 "C90" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E9F" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833E9F" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A2/65833E9F" Ref="C78"  Part="1"
-F 0 "C78" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A2/65833E9F" Ref="C89"  Part="1"
+F 0 "C89" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EA3" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EA3" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833EA3" Ref="#PWR0219"  Part="1"
-F 0 "#PWR0219" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833EA3" Ref="#PWR0233"  Part="1"
+F 0 "#PWR0233" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EB9" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EB9" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833EB9" Ref="#PWR0215"  Part="1"
-F 0 "#PWR0215" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833EB9" Ref="#PWR0229"  Part="1"
+F 0 "#PWR0229" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ECA" Ref="Y?"  Part="1"
 AR Path="/6174477C/6577909A/65833ECA" Ref="Y?"  Part="1"
-AR Path="/6174477C/657790A2/65833ECA" Ref="Y15"  Part="1"
-F 0 "Y15" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/657790A2/65833ECA" Ref="Y17"  Part="1"
+F 0 "Y17" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E00" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E00" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833E00" Ref="#PWR0216"  Part="1"
-F 0 "#PWR0216" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833E00" Ref="#PWR0230"  Part="1"
+F 0 "#PWR0230" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E15" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E15" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833E15" Ref="#PWR0217"  Part="1"
-F 0 "#PWR0217" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833E15" Ref="#PWR0231"  Part="1"
+F 0 "#PWR0231" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DD0" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833DD0" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A2/65833DD0" Ref="R109"  Part="1"
-F 0 "R109" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/657790A2/65833DD0" Ref="R87"  Part="1"
+F 0 "R87" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E23" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E23" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833E23" Ref="#PWR0210"  Part="1"
-F 0 "#PWR0210" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833E23" Ref="#PWR0224"  Part="1"
+F 0 "#PWR0224" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E34" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E34" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833E34" Ref="#PWR0213"  Part="1"
-F 0 "#PWR0213" H 4700 2600 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833E34" Ref="#PWR0227"  Part="1"
+F 0 "#PWR0227" H 4700 2600 50  0001 C CNN
 F 1 "GND" H 4705 2677 50  0000 C CNN
 F 2 "" H 4700 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E45" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E45" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A2/65833E45" Ref="R110"  Part="1"
-F 0 "R110" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/657790A2/65833E45" Ref="R88"  Part="1"
+F 0 "R88" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E54" Ref="J?"  Part="1"
 AR Path="/6174477C/6577909A/65833E54" Ref="J?"  Part="1"
-AR Path="/6174477C/657790A2/65833E54" Ref="J21"  Part="1"
-F 0 "J21" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/657790A2/65833E54" Ref="J25"  Part="1"
+F 0 "J25" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E57" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E57" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833E57" Ref="#PWR0212"  Part="1"
-F 0 "#PWR0212" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833E57" Ref="#PWR0226"  Part="1"
+F 0 "#PWR0226" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E6B" Ref="D?"  Part="1"
 AR Path="/6174477C/6577909A/65833E6B" Ref="D?"  Part="1"
-AR Path="/6174477C/657790A2/65833E6B" Ref="D20"  Part="1"
-F 0 "D20" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/657790A2/65833E6B" Ref="D22"  Part="1"
+F 0 "D22" V 8439 2682 50  0000 R CNN
 F 1 "NODE12_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E75" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E75" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A2/65833E75" Ref="R111"  Part="1"
-F 0 "R111" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/657790A2/65833E75" Ref="R89"  Part="1"
+F 0 "R89" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EF5" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EF5" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833EF5" Ref="#PWR0218"  Part="1"
-F 0 "#PWR0218" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833EF5" Ref="#PWR0232"  Part="1"
+F 0 "#PWR0232" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DC1" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DC1" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A2/65833DC1" Ref="#PWR0214"  Part="1"
-F 0 "#PWR0214" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/657790A2/65833DC1" Ref="#PWR0228"  Part="1"
+F 0 "#PWR0228" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
