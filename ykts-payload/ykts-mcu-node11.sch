File: ykts-payload/ykts-mcu-node11.sch (KiCad schematic (older format))
At the start: 12 parts, among them J19 AVR-ISP-6, SW12 ADG802BRT, U25 ATmega328PB-MU, Y14 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D20 to D19, J19 to J20, R102 to R106, R103 to R107, R104 to R108
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 13 18
+Sheet 14 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/63801AF0/63916979" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/63916979" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/63916979" Ref="#PWR0199"  Part="1"
-F 0 "#PWR0199" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF121/63916979" Ref="#PWR0201"  Part="1"
+F 0 "#PWR0201" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391697B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391697B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/6391697B" Ref="#PWR0207"  Part="1"
-F 0 "#PWR0207" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF121/6391697B" Ref="#PWR0209"  Part="1"
+F 0 "#PWR0209" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391656A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/6391656A" Ref="#PWR0203"  Part="1"
-F 0 "#PWR0203" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF121/6391656A" Ref="#PWR0205"  Part="1"
+F 0 "#PWR0205" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916579" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/63916579" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/63916579" Ref="#PWR0204"  Part="1"
-F 0 "#PWR0204" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF121/63916579" Ref="#PWR0206"  Part="1"
+F 0 "#PWR0206" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391657A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391657A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/6391657A" Ref="#PWR0205"  Part="1"
-F 0 "#PWR0205" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF121/6391657A" Ref="#PWR0207"  Part="1"
+F 0 "#PWR0207" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916973" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/63916973" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF121/63916973" Ref="R102"  Part="1"
-F 0 "R102" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF121/63916973" Ref="R106"  Part="1"
+F 0 "R106" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916978" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/63916978" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/63916978" Ref="#PWR0198"  Part="1"
-F 0 "#PWR0198" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF121/63916978" Ref="#PWR0200"  Part="1"
+F 0 "#PWR0200" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656C" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391656C" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/6391656C" Ref="#PWR0201"  Part="1"
-F 0 "#PWR0201" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF121/6391656C" Ref="#PWR0203"  Part="1"
+F 0 "#PWR0203" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916575" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/63916575" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF121/63916575" Ref="R103"  Part="1"
-F 0 "R103" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF121/63916575" Ref="R107"  Part="1"
+F 0 "R107" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916576" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BC/63916576" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF121/63916576" Ref="J19"  Part="1"
-F 0 "J19" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF121/63916576" Ref="J20"  Part="1"
+F 0 "J20" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916985" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/63916985" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/63916985" Ref="#PWR0200"  Part="1"
-F 0 "#PWR0200" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF121/63916985" Ref="#PWR0202"  Part="1"
+F 0 "#PWR0202" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916974" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BC/63916974" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF121/63916974" Ref="D20"  Part="1"
-F 0 "D20" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF121/63916974" Ref="D19"  Part="1"
+F 0 "D19" V 8439 2682 50  0000 R CNN
 F 1 "NODE11_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63797BAD" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/63797BAD" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF121/63797BAD" Ref="R104"  Part="1"
-F 0 "R104" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF121/63797BAD" Ref="R108"  Part="1"
+F 0 "R108" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391697E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391697E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/6391697E" Ref="#PWR0206"  Part="1"
-F 0 "#PWR0206" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF121/6391697E" Ref="#PWR0208"  Part="1"
+F 0 "#PWR0208" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916977" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/63916977" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF121/63916977" Ref="#PWR0202"  Part="1"
-F 0 "#PWR0202" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF121/63916977" Ref="#PWR0204"  Part="1"
+F 0 "#PWR0204" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C72.1, C73.1, D19.2 (A), R106.2, U25.18 (AVCC), U25.20 (AREF), U25.4 (VCC)
- net at SW12.1 (D): now also C72.1, C73.1, D19.2 (A), R106.2, U25.18 (AVCC), U25.20 (AREF), U25.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J20: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J20" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
