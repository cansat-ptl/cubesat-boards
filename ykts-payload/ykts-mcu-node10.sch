File: ykts-payload/ykts-mcu-node10.sch (KiCad schematic (older format))
At the start: 12 parts, among them J15 AVR-ISP-6, SW10 ADG802BRT, U23 ATmega328PB-MU, Y12 8 MHz

Commit message: Fixed annotations & sheet ordering
Parts:
- renumbered C64 to C68, C65 to C69, C66 to C70, C67 to C71, D15 to D19, J15 to J18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
Changed lines of the file:
@@
 Sheet 12 18
 Title "YktSat Payload Module"
-Date "2021-09-30"
-Rev "A0"
+Date "2021-10-02"
+Rev "A1"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/638385BA/6391686F" Ref="U?"  Part="1"
 AR Path="/6174477C/638DF11D/6391686F" Ref="U?"  Part="1"
-AR Path="/6174477C/638DF11F/6391686F" Ref="U23"  Part="1"
-F 0 "U23" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/638DF11F/6391686F" Ref="U24"  Part="1"
+F 0 "U24" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/638385BA/63916878" Ref="SW?"  Part="1"
 AR Path="/6174477C/638DF11D/63916878" Ref="SW?"  Part="1"
-AR Path="/6174477C/638DF11F/63916878" Ref="SW10"  Part="1"
-F 0 "SW10" H 3500 2631 50  0000 C CNN
+AR Path="/6174477C/638DF11F/63916878" Ref="SW11"  Part="1"
+F 0 "SW11" H 3500 2631 50  0000 C CNN
 F 1 "ADG802BRT" H 3500 2540 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:SOT-23-6" H 3500 2500 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916879" Ref="C?"  Part="1"
 AR Path="/6174477C/638DF11D/63916879" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF11F/63916879" Ref="C64"  Part="1"
-F 0 "C64" H 4292 2646 50  0000 L CNN
+AR Path="/6174477C/638DF11F/63916879" Ref="C68"  Part="1"
+F 0 "C68" H 4292 2646 50  0000 L CNN
 F 1 "1uF" H 4292 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4200 2600 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687A" Ref="C?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687A" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687A" Ref="C65"  Part="1"
-F 0 "C65" H 4642 2646 50  0000 L CNN
+AR Path="/6174477C/638DF11F/6391687A" Ref="C69"  Part="1"
+F 0 "C69" H 4642 2646 50  0000 L CNN
 F 1 "100nF" H 4642 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4550 2600 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687B" Ref="#PWR0247"  Part="1"
-F 0 "#PWR0247" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687B" Ref="#PWR0189"  Part="1"
+F 0 "#PWR0189" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F03C" Ref="C?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F03C" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F03C" Ref="C67"  Part="1"
-F 0 "C67" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF11F/6386F03C" Ref="C71"  Part="1"
+F 0 "C71" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916884" Ref="C?"  Part="1"
 AR Path="/6174477C/638DF11D/63916884" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF11F/63916884" Ref="C66"  Part="1"
-F 0 "C66" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF11F/63916884" Ref="C70"  Part="1"
+F 0 "C70" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687F" Ref="#PWR0248"  Part="1"
-F 0 "#PWR0248" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687F" Ref="#PWR0197"  Part="1"
+F 0 "#PWR0197" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916880" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916880" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916880" Ref="#PWR0249"  Part="1"
-F 0 "#PWR0249" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916880" Ref="#PWR0193"  Part="1"
+F 0 "#PWR0193" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F034" Ref="Y?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F034" Ref="Y?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F034" Ref="Y12"  Part="1"
-F 0 "Y12" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/638DF11F/6386F034" Ref="Y13"  Part="1"
+F 0 "Y13" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687D" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687D" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687D" Ref="#PWR0250"  Part="1"
-F 0 "#PWR0250" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687D" Ref="#PWR0194"  Part="1"
+F 0 "#PWR0194" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916870" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916870" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916870" Ref="#PWR0251"  Part="1"
-F 0 "#PWR0251" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916870" Ref="#PWR0195"  Part="1"
+F 0 "#PWR0195" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386EE39" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/6386EE39" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/6386EE39" Ref="R86"  Part="1"
-F 0 "R86" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF11F/6386EE39" Ref="R99"  Part="1"
+F 0 "R99" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F03F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F03F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F03F" Ref="#PWR0252"  Part="1"
-F 0 "#PWR0252" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6386F03F" Ref="#PWR0188"  Part="1"
+F 0 "#PWR0188" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916881" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916881" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916881" Ref="#PWR0253"  Part="1"
-F 0 "#PWR0253" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916881" Ref="#PWR0191"  Part="1"
+F 0 "#PWR0191" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916875" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/63916875" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/63916875" Ref="R87"  Part="1"
-F 0 "R87" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF11F/63916875" Ref="R100"  Part="1"
+F 0 "R100" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916876" Ref="J?"  Part="1"
 AR Path="/6174477C/638DF11D/63916876" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF11F/63916876" Ref="J15"  Part="1"
-F 0 "J15" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF11F/63916876" Ref="J18"  Part="1"
+F 0 "J18" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916877" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916877" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916877" Ref="#PWR0254"  Part="1"
-F 0 "#PWR0254" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916877" Ref="#PWR0190"  Part="1"
+F 0 "#PWR0190" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386EE3F" Ref="D?"  Part="1"
 AR Path="/6174477C/638DF11D/6386EE3F" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF11F/6386EE3F" Ref="D15"  Part="1"
-F 0 "D15" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF11F/6386EE3F" Ref="D19"  Part="1"
+F 0 "D19" V 8439 2682 50  0000 R CNN
 F 1 "NODE10_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F047" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F047" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F047" Ref="R88"  Part="1"
-F 0 "R88" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF11F/6386F047" Ref="R101"  Part="1"
+F 0 "R101" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F048" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F048" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F048" Ref="#PWR0255"  Part="1"
-F 0 "#PWR0255" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6386F048" Ref="#PWR0196"  Part="1"
+F 0 "#PWR0196" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916871" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916871" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916871" Ref="#PWR0256"  Part="1"
-F 0 "#PWR0256" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916871" Ref="#PWR0192"  Part="1"
+F 0 "#PWR0192" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
