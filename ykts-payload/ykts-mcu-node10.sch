File: ykts-payload/ykts-mcu-node10.sch (KiCad schematic (older format))
At the start: 12 parts, among them J18 AVR-ISP-6, SW11 ADG802BRT, U24 ATmega328PB-MU, Y13 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D19 to D18, J18 to J19, R99 to R103, R100 to R104, R101 to R105
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 12 18
+Sheet 13 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/638385BA/6391687B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687B" Ref="#PWR0189"  Part="1"
-F 0 "#PWR0189" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687B" Ref="#PWR0191"  Part="1"
+F 0 "#PWR0191" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687F" Ref="#PWR0197"  Part="1"
-F 0 "#PWR0197" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687F" Ref="#PWR0199"  Part="1"
+F 0 "#PWR0199" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916880" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916880" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916880" Ref="#PWR0193"  Part="1"
-F 0 "#PWR0193" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916880" Ref="#PWR0195"  Part="1"
+F 0 "#PWR0195" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6391687D" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6391687D" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6391687D" Ref="#PWR0194"  Part="1"
-F 0 "#PWR0194" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6391687D" Ref="#PWR0196"  Part="1"
+F 0 "#PWR0196" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916870" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916870" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916870" Ref="#PWR0195"  Part="1"
-F 0 "#PWR0195" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916870" Ref="#PWR0197"  Part="1"
+F 0 "#PWR0197" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386EE39" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/6386EE39" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/6386EE39" Ref="R99"  Part="1"
-F 0 "R99" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF11F/6386EE39" Ref="R103"  Part="1"
+F 0 "R103" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F03F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F03F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F03F" Ref="#PWR0188"  Part="1"
-F 0 "#PWR0188" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6386F03F" Ref="#PWR0190"  Part="1"
+F 0 "#PWR0190" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916881" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916881" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916881" Ref="#PWR0191"  Part="1"
-F 0 "#PWR0191" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916881" Ref="#PWR0193"  Part="1"
+F 0 "#PWR0193" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916875" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/63916875" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/63916875" Ref="R100"  Part="1"
-F 0 "R100" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF11F/63916875" Ref="R104"  Part="1"
+F 0 "R104" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916876" Ref="J?"  Part="1"
 AR Path="/6174477C/638DF11D/63916876" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF11F/63916876" Ref="J18"  Part="1"
-F 0 "J18" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF11F/63916876" Ref="J19"  Part="1"
+F 0 "J19" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916877" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916877" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916877" Ref="#PWR0190"  Part="1"
-F 0 "#PWR0190" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916877" Ref="#PWR0192"  Part="1"
+F 0 "#PWR0192" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386EE3F" Ref="D?"  Part="1"
 AR Path="/6174477C/638DF11D/6386EE3F" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF11F/6386EE3F" Ref="D19"  Part="1"
-F 0 "D19" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF11F/6386EE3F" Ref="D18"  Part="1"
+F 0 "D18" V 8439 2682 50  0000 R CNN
 F 1 "NODE10_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F047" Ref="R?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F047" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F047" Ref="R101"  Part="1"
-F 0 "R101" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF11F/6386F047" Ref="R105"  Part="1"
+F 0 "R105" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/6386F048" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/6386F048" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/6386F048" Ref="#PWR0196"  Part="1"
-F 0 "#PWR0196" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF11F/6386F048" Ref="#PWR0198"  Part="1"
+F 0 "#PWR0198" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/638385BA/63916871" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638DF11D/63916871" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF11F/63916871" Ref="#PWR0192"  Part="1"
-F 0 "#PWR0192" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF11F/63916871" Ref="#PWR0194"  Part="1"
+F 0 "#PWR0194" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C68.1, C69.1, D18.2 (A), R103.2, U24.18 (AVCC), U24.20 (AREF), U24.4 (VCC)
- net at SW11.1 (D): now also C68.1, C69.1, D18.2 (A), R103.2, U24.18 (AVCC), U24.20 (AREF), U24.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J19: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J19" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
