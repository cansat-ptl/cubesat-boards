File: ykts-payload/ykts-payload.sch (KiCad schematic (older format))
At the start: 53 parts, among them J1 PC/104 Connector, J2 DBG_PWR, Q1 KIA3415, U1 MAX4372FEUK, U2 MAX4372FEUK, U3 MCP2515-xST, U4 MCP2515-xST, U5 TJA1051T-3, U6 TJA1051T-3, Y1 12MHz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

Commit message: Revision C0
Basic OC protection on 5V_A & 5V_B
SD Card -> SPI Flash
MCU Node boards
Parts:
- added F1, F2: Polyfuse, Resistor_SMD:R_0805_2012Metric, symbol Device:Polyfuse
Connections:
- net +5V: now also F1.1, F2.1; no longer C1.1, C10.1, C13.1, C14.1, C2.1, C7.1, C8.1, C9.1, R10.1, R9.1, R_CSA1.2, R_CSB1.2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
- net +5V_A: now also C1.1, C13.1, C7.1, C9.1, R9.1, U1.3 (VCC), U3.20 (VDD), U5.3 (VCC), U5.5 (VIO)
- net +5V_B: now also C10.1, C14.1, C2.1, C8.1, R10.1, U2.3 (VCC), U4.20 (VDD), U6.3 (VCC), U6.5 (VIO)
- new net: F1.2, R_CSA1.2, U1.4 (RS+)
- new net: F2.2, R_CSB1.2, U2.4 (RS+)
Other:
- moved on the sheet: C1, C2, R_CSA1, U1, U2

Commit message: Revision C1
Added CH_A & CH_B power control switches
Parts:
- removed F1, F2: Polyfuse, Resistor_SMD:R_0805_2012Metric, symbol Device:Polyfuse
- removed Q1: KIA3415, Package_TO_SOT_SMD:SOT-23, symbol Device:Q_PMOS_GSD
- added Q1, Q2, Q3: PMV65XP, symbol Device:Q_PMOS_GDS
- added R47, R49: 1K, Resistor_SMD:R_0402_1005Metric, symbol Device:R_Small
- added R48, R50: 10K, Resistor_SMD:R_0402_1005Metric, symbol Device:R_Small
Connections:
- net +5V: now also Q1.3 (S), Q2.3 (S), Q3.3 (S)
- net +5V_GEIGER: now also Q3.2 (D)
- net GND: now also R48.1, R50.1
- net CH_A: now reaches J1.a31 (Pin_a31)
- net CH_A: now also R47.2
- net CH_B: now reaches J1.b31 (Pin_b31)
- net CH_B: now also R49.2
- net at R_CSA1.2, U1.4 (RS+): now also Q1.2 (D)
- net at R_CSB1.2, U2.4 (RS+): now also Q2.2 (D)
- net at R5.1, R6.2: now also Q3.1 (G)
- new net: Q2.1 (G), R49.1, R50.2
- new net: Q1.1 (G), R47.1, R48.2
Other:
- note added: "P-channel MOSFET\nSOT-23 package\n1A MAX, NC"
- note added: "P-channel MOSFETs\nSOT-23 package\n1A MAX, NO"
- note removed: "P-channel MOSFET\nSOT-23 package\n1A MAX"
- moved on the sheet: C1, C2, R_CSA1, R_CSB1, U1, U2
