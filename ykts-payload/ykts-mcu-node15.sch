File: ykts-payload/ykts-mcu-node15.sch (KiCad schematic (older format))
At the start: 12 parts, among them J24 AVR-ISP-6, SW16 ADG802BRT, U29 ATmega328PB-MU, Y18 8 MHz

Commit message: Revision B0
Added second supervisor, mega2560 -> mega128a
Parts:
- renumbered C89 to C100, C90 to C101, C91 to C102, C88 to C99, D23 to D25, J24 to J28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
Changed lines of the file:
@@
 Sheet 18 18
 Title "YktSat Payload Module"
-Date "2021-10-03"
-Rev "A3"
+Date "2021-10-22"
+Rev "B0"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/6572958C/65833EE4" Ref="U?"  Part="1"
 AR Path="/6174477C/6577909A/65833EE4" Ref="U?"  Part="1"
-AR Path="/6174477C/657790A8/65833EE4" Ref="U29"  Part="1"
-F 0 "U29" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/657790A8/65833EE4" Ref="U27"  Part="1"
+F 0 "U27" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/6572958C/65833DB5" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DB5" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A8/65833DB5" Ref="C88"  Part="1"
-F 0 "C88" H 4442 2646 50  0000 L CNN
+AR Path="/6174477C/657790A8/65833DB5" Ref="C99"  Part="1"
+F 0 "C99" H 4442 2646 50  0000 L CNN
 F 1 "1uF" H 4442 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4350 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EDD" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833EDD" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A8/65833EDD" Ref="C89"  Part="1"
-F 0 "C89" H 4792 2646 50  0000 L CNN
+AR Path="/6174477C/657790A8/65833EDD" Ref="C100"  Part="1"
+F 0 "C100" H 4792 2646 50  0000 L CNN
 F 1 "100nF" H 4792 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4700 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DE8" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DE8" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833DE8" Ref="#PWR0241"  Part="1"
-F 0 "#PWR0241" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833DE8" Ref="#PWR0255"  Part="1"
+F 0 "#PWR0255" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DF9" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DF9" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A8/65833DF9" Ref="C91"  Part="1"
-F 0 "C91" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A8/65833DF9" Ref="C102"  Part="1"
+F 0 "C102" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/6391666C" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/6391666C" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A8/6391666C" Ref="C90"  Part="1"
-F 0 "C90" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A8/6391666C" Ref="C101"  Part="1"
+F 0 "C101" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EA7" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EA7" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833EA7" Ref="#PWR0249"  Part="1"
-F 0 "#PWR0249" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833EA7" Ref="#PWR0263"  Part="1"
+F 0 "#PWR0263" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EB1" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EB1" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833EB1" Ref="#PWR0245"  Part="1"
-F 0 "#PWR0245" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833EB1" Ref="#PWR0259"  Part="1"
+F 0 "#PWR0259" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EC3" Ref="Y?"  Part="1"
 AR Path="/6174477C/6577909A/65833EC3" Ref="Y?"  Part="1"
-AR Path="/6174477C/657790A8/65833EC3" Ref="Y18"  Part="1"
-F 0 "Y18" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/657790A8/65833EC3" Ref="Y20"  Part="1"
+F 0 "Y20" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E03" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E03" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833E03" Ref="#PWR0246"  Part="1"
-F 0 "#PWR0246" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833E03" Ref="#PWR0260"  Part="1"
+F 0 "#PWR0260" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E17" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E17" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833E17" Ref="#PWR0247"  Part="1"
-F 0 "#PWR0247" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833E17" Ref="#PWR0261"  Part="1"
+F 0 "#PWR0261" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DD9" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833DD9" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A8/65833DD9" Ref="R118"  Part="1"
-F 0 "R118" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/657790A8/65833DD9" Ref="R96"  Part="1"
+F 0 "R96" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E1F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E1F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833E1F" Ref="#PWR0240"  Part="1"
-F 0 "#PWR0240" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833E1F" Ref="#PWR0254"  Part="1"
+F 0 "#PWR0254" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E2F" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E2F" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833E2F" Ref="#PWR0243"  Part="1"
-F 0 "#PWR0243" H 4700 2600 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833E2F" Ref="#PWR0257"  Part="1"
+F 0 "#PWR0257" H 4700 2600 50  0001 C CNN
 F 1 "GND" H 4705 2677 50  0000 C CNN
 F 2 "" H 4700 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E47" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E47" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A8/65833E47" Ref="R119"  Part="1"
-F 0 "R119" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/657790A8/65833E47" Ref="R97"  Part="1"
+F 0 "R97" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E4A" Ref="J?"  Part="1"
 AR Path="/6174477C/6577909A/65833E4A" Ref="J?"  Part="1"
-AR Path="/6174477C/657790A8/65833E4A" Ref="J24"  Part="1"
-F 0 "J24" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/657790A8/65833E4A" Ref="J28"  Part="1"
+F 0 "J28" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E5B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E5B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833E5B" Ref="#PWR0242"  Part="1"
-F 0 "#PWR0242" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833E5B" Ref="#PWR0256"  Part="1"
+F 0 "#PWR0256" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E6C" Ref="D?"  Part="1"
 AR Path="/6174477C/6577909A/65833E6C" Ref="D?"  Part="1"
-AR Path="/6174477C/657790A8/65833E6C" Ref="D23"  Part="1"
-F 0 "D23" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/657790A8/65833E6C" Ref="D25"  Part="1"
+F 0 "D25" V 8439 2682 50  0000 R CNN
 F 1 "NODE15_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E83" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E83" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A8/65833E83" Ref="R120"  Part="1"
-F 0 "R120" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/657790A8/65833E83" Ref="R98"  Part="1"
+F 0 "R98" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EF3" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EF3" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833EF3" Ref="#PWR0248"  Part="1"
-F 0 "#PWR0248" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833EF3" Ref="#PWR0262"  Part="1"
+F 0 "#PWR0262" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DCF" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DCF" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A8/65833DCF" Ref="#PWR0244"  Part="1"
-F 0 "#PWR0244" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/657790A8/65833DCF" Ref="#PWR0258"  Part="1"
+F 0 "#PWR0258" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
