File: ykts-payload/ykts-mcu-node15.sch (KiCad schematic (older format))
At the start: 12 parts, among them J20 AVR-ISP-6, SW15 ADG802BRT, U28 ATmega328PB-MU, Y17 8 MHz

Commit message: Fixed annotations & sheet ordering
Parts:
- renumbered C84 to C88, C85 to C89, C86 to C90, C87 to C91, D20 to D24, J20 to J23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
Changed lines of the file:
@@
 Sheet 17 18
 Title "YktSat Payload Module"
-Date "2021-09-30"
-Rev "A0"
+Date "2021-10-02"
+Rev "A1"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/63801AF0/639B62CB" Ref="U?"  Part="1"
 AR Path="/6174477C/638385BC/639B62CB" Ref="U?"  Part="1"
-AR Path="/6174477C/638DF129/639B62CB" Ref="U28"  Part="1"
-F 0 "U28" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/638DF129/639B62CB" Ref="U29"  Part="1"
+F 0 "U29" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/63801AF0/639B62BE" Ref="SW?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BE" Ref="SW?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BE" Ref="SW15"  Part="1"
-F 0 "SW15" H 3500 2631 50  0000 C CNN
+AR Path="/6174477C/638DF129/639B62BE" Ref="SW16"  Part="1"
+F 0 "SW16" H 3500 2631 50  0000 C CNN
 F 1 "ADG802BRT" H 3500 2540 50  0000 C CNN
 F 2 "Package_TO_SOT_SMD:SOT-23-6" H 3500 2500 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BF" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BF" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BF" Ref="C84"  Part="1"
-F 0 "C84" H 4292 2646 50  0000 L CNN
+AR Path="/6174477C/638DF129/639B62BF" Ref="C88"  Part="1"
+F 0 "C88" H 4292 2646 50  0000 L CNN
 F 1 "1uF" H 4292 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4200 2600 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C0" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C0" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C0" Ref="C85"  Part="1"
-F 0 "C85" H 4642 2646 50  0000 L CNN
+AR Path="/6174477C/638DF129/639B62C0" Ref="C89"  Part="1"
+F 0 "C89" H 4642 2646 50  0000 L CNN
 F 1 "100nF" H 4642 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4550 2600 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62B8" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62B8" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62B8" Ref="#PWR0297"  Part="1"
-F 0 "#PWR0297" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62B8" Ref="#PWR0239"  Part="1"
+F 0 "#PWR0239" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/63916567" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BC/63916567" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF129/63916567" Ref="C87"  Part="1"
-F 0 "C87" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF129/63916567" Ref="C91"  Part="1"
+F 0 "C91" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62B9" Ref="C?"  Part="1"
 AR Path="/6174477C/638385BC/639B62B9" Ref="C?"  Part="1"
-AR Path="/6174477C/638DF129/639B62B9" Ref="C86"  Part="1"
-F 0 "C86" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/638DF129/639B62B9" Ref="C90"  Part="1"
+F 0 "C90" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BA" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BA" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BA" Ref="#PWR0298"  Part="1"
-F 0 "#PWR0298" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BA" Ref="#PWR0247"  Part="1"
+F 0 "#PWR0247" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BB" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BB" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BB" Ref="#PWR0299"  Part="1"
-F 0 "#PWR0299" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BB" Ref="#PWR0243"  Part="1"
+F 0 "#PWR0243" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6386EE36" Ref="Y?"  Part="1"
 AR Path="/6174477C/638385BC/6386EE36" Ref="Y?"  Part="1"
-AR Path="/6174477C/638DF129/6386EE36" Ref="Y17"  Part="1"
-F 0 "Y17" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/638DF129/6386EE36" Ref="Y18"  Part="1"
+F 0 "Y18" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6386EF35" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6386EF35" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6386EF35" Ref="#PWR0300"  Part="1"
-F 0 "#PWR0300" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF129/6386EF35" Ref="#PWR0244"  Part="1"
+F 0 "#PWR0244" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6386EF36" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6386EF36" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6386EF36" Ref="#PWR0301"  Part="1"
-F 0 "#PWR0301" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF129/6386EF36" Ref="#PWR0245"  Part="1"
+F 0 "#PWR0245" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656B" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/6391656B" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/6391656B" Ref="R101"  Part="1"
-F 0 "R101" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF129/6391656B" Ref="R114"  Part="1"
+F 0 "R114" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391657B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391657B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6391657B" Ref="#PWR0302"  Part="1"
-F 0 "#PWR0302" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF129/6391657B" Ref="#PWR0238"  Part="1"
+F 0 "#PWR0238" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BC" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BC" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BC" Ref="#PWR0303"  Part="1"
-F 0 "#PWR0303" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BC" Ref="#PWR0241"  Part="1"
+F 0 "#PWR0241" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C2" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C2" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C2" Ref="R102"  Part="1"
-F 0 "R102" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF129/639B62C2" Ref="R115"  Part="1"
+F 0 "R115" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C3" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C3" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C3" Ref="J20"  Part="1"
-F 0 "J20" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF129/639B62C3" Ref="J23"  Part="1"
+F 0 "J23" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C4" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C4" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C4" Ref="#PWR0304"  Part="1"
-F 0 "#PWR0304" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62C4" Ref="#PWR0240"  Part="1"
+F 0 "#PWR0240" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C9" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C9" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C9" Ref="D20"  Part="1"
-F 0 "D20" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF129/639B62C9" Ref="D24"  Part="1"
+F 0 "D24" V 8439 2682 50  0000 R CNN
 F 1 "NODE15_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656E" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/6391656E" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/6391656E" Ref="R103"  Part="1"
-F 0 "R103" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF129/6391656E" Ref="R116"  Part="1"
+F 0 "R116" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BD" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BD" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BD" Ref="#PWR0305"  Part="1"
-F 0 "#PWR0305" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BD" Ref="#PWR0246"  Part="1"
+F 0 "#PWR0246" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62CC" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62CC" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62CC" Ref="#PWR0306"  Part="1"
-F 0 "#PWR0306" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62CC" Ref="#PWR0242"  Part="1"
+F 0 "#PWR0242" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
