File: ykts-payload/ykts-mcu-node15.sch (KiCad schematic (older format))
At the start: 12 parts, among them J23 AVR-ISP-6, SW16 ADG802BRT, U29 ATmega328PB-MU, Y18 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D24 to D23, J23 to J24, R114 to R118, R115 to R119, R116 to R120
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 17 18
+Sheet 18 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/63801AF0/639B62B8" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62B8" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62B8" Ref="#PWR0239"  Part="1"
-F 0 "#PWR0239" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62B8" Ref="#PWR0241"  Part="1"
+F 0 "#PWR0241" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BA" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BA" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BA" Ref="#PWR0247"  Part="1"
-F 0 "#PWR0247" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BA" Ref="#PWR0249"  Part="1"
+F 0 "#PWR0249" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BB" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BB" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BB" Ref="#PWR0243"  Part="1"
-F 0 "#PWR0243" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BB" Ref="#PWR0245"  Part="1"
+F 0 "#PWR0245" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6386EF35" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6386EF35" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6386EF35" Ref="#PWR0244"  Part="1"
-F 0 "#PWR0244" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF129/6386EF35" Ref="#PWR0246"  Part="1"
+F 0 "#PWR0246" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6386EF36" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6386EF36" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6386EF36" Ref="#PWR0245"  Part="1"
-F 0 "#PWR0245" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF129/6386EF36" Ref="#PWR0247"  Part="1"
+F 0 "#PWR0247" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656B" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/6391656B" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/6391656B" Ref="R114"  Part="1"
-F 0 "R114" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF129/6391656B" Ref="R118"  Part="1"
+F 0 "R118" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391657B" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/6391657B" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/6391657B" Ref="#PWR0238"  Part="1"
-F 0 "#PWR0238" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF129/6391657B" Ref="#PWR0240"  Part="1"
+F 0 "#PWR0240" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BC" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BC" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BC" Ref="#PWR0241"  Part="1"
-F 0 "#PWR0241" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BC" Ref="#PWR0243"  Part="1"
+F 0 "#PWR0243" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C2" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C2" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C2" Ref="R115"  Part="1"
-F 0 "R115" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF129/639B62C2" Ref="R119"  Part="1"
+F 0 "R119" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C3" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C3" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C3" Ref="J23"  Part="1"
-F 0 "J23" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF129/639B62C3" Ref="J24"  Part="1"
+F 0 "J24" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C4" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C4" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C4" Ref="#PWR0240"  Part="1"
-F 0 "#PWR0240" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62C4" Ref="#PWR0242"  Part="1"
+F 0 "#PWR0242" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62C9" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BC/639B62C9" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF129/639B62C9" Ref="D24"  Part="1"
-F 0 "D24" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF129/639B62C9" Ref="D23"  Part="1"
+F 0 "D23" V 8439 2682 50  0000 R CNN
 F 1 "NODE15_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/6391656E" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BC/6391656E" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF129/6391656E" Ref="R116"  Part="1"
-F 0 "R116" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF129/6391656E" Ref="R120"  Part="1"
+F 0 "R120" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62BD" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62BD" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62BD" Ref="#PWR0246"  Part="1"
-F 0 "#PWR0246" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62BD" Ref="#PWR0248"  Part="1"
+F 0 "#PWR0248" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/63801AF0/639B62CC" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BC/639B62CC" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF129/639B62CC" Ref="#PWR0242"  Part="1"
-F 0 "#PWR0242" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF129/639B62CC" Ref="#PWR0244"  Part="1"
+F 0 "#PWR0244" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C88.1, C89.1, D23.2 (A), R118.2, U29.18 (AVCC), U29.20 (AREF), U29.4 (VCC)
- net at SW16.1 (D): now also C88.1, C89.1, D23.2 (A), R118.2, U29.18 (AVCC), U29.20 (AREF), U29.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J24: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J24" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
