File: ykts-payload/ykts-mcu-node14.sch (KiCad schematic (older format))
At the start: 12 parts, among them J23 AVR-ISP-6, SW15 ADG802BRT, U28 ATmega328PB-MU, Y17 8 MHz

Commit message: Revision B0
Added second supervisor, mega2560 -> mega128a
Parts:
- renumbered C84 to C95, C85 to C96, C86 to C97, C87 to C98, D22 to D24, J23 to J27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
Changed lines of the file:
@@
 Sheet 17 18
 Title "YktSat Payload Module"
-Date "2021-10-03"
-Rev "A3"
+Date "2021-10-22"
+Rev "B0"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/6572958C/65833EE2" Ref="U?"  Part="1"
 AR Path="/6174477C/6577909A/65833EE2" Ref="U?"  Part="1"
-AR Path="/6174477C/657790A6/65833EE2" Ref="U28"  Part="1"
-F 0 "U28" H 6100 2711 50  0000 C CNN
+AR Path="/6174477C/657790A6/65833EE2" Ref="U26"  Part="1"
+F 0 "U26" H 6100 2711 50  0000 C CNN
 F 1 "ATmega328PB-MU" H 6100 2620 50  0000 C CNN
 F 2 "Package_DFN_QFN:QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm" H 6100 4300 50  0001 C CIN
@@
 AR Path="/6174477C/6572958C/6375CEE6" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/6375CEE6" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A6/6375CEE6" Ref="C84"  Part="1"
-F 0 "C84" H 4442 2646 50  0000 L CNN
+AR Path="/6174477C/657790A6/6375CEE6" Ref="C95"  Part="1"
+F 0 "C95" H 4442 2646 50  0000 L CNN
 F 1 "1uF" H 4442 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0603_1608Metric" H 4350 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ECF" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833ECF" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A6/65833ECF" Ref="C85"  Part="1"
-F 0 "C85" H 4792 2646 50  0000 L CNN
+AR Path="/6174477C/657790A6/65833ECF" Ref="C96"  Part="1"
+F 0 "C96" H 4792 2646 50  0000 L CNN
 F 1 "100nF" H 4792 2555 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 4700 2600 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DE4" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DE4" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833DE4" Ref="#PWR0231"  Part="1"
-F 0 "#PWR0231" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833DE4" Ref="#PWR0245"  Part="1"
+F 0 "#PWR0245" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DFB" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833DFB" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A6/65833DFB" Ref="C87"  Part="1"
-F 0 "C87" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A6/65833DFB" Ref="C98"  Part="1"
+F 0 "C98" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8400 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E9A" Ref="C?"  Part="1"
 AR Path="/6174477C/6577909A/65833E9A" Ref="C?"  Part="1"
-AR Path="/6174477C/657790A6/65833E9A" Ref="C86"  Part="1"
-F 0 "C86" H 8100 4600 50  0000 L CNN
+AR Path="/6174477C/657790A6/65833E9A" Ref="C97"  Part="1"
+F 0 "C97" H 8100 4600 50  0000 L CNN
 F 1 "22pF" H 8100 4500 50  0000 L CNN
 F 2 "Capacitor_SMD:C_0402_1005Metric" H 8000 4550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EA9" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EA9" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833EA9" Ref="#PWR0239"  Part="1"
-F 0 "#PWR0239" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833EA9" Ref="#PWR0253"  Part="1"
+F 0 "#PWR0253" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EBD" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EBD" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833EBD" Ref="#PWR0235"  Part="1"
-F 0 "#PWR0235" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833EBD" Ref="#PWR0249"  Part="1"
+F 0 "#PWR0249" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833ECC" Ref="Y?"  Part="1"
 AR Path="/6174477C/6577909A/65833ECC" Ref="Y?"  Part="1"
-AR Path="/6174477C/657790A6/65833ECC" Ref="Y17"  Part="1"
-F 0 "Y17" H 8450 4350 50  0000 L CNN
+AR Path="/6174477C/657790A6/65833ECC" Ref="Y19"  Part="1"
+F 0 "Y19" H 8450 4350 50  0000 L CNN
 F 1 "8 MHz" H 8450 4250 50  0000 L CNN
 F 2 "Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm" H 8200 4300 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DFE" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833DFE" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833DFE" Ref="#PWR0236"  Part="1"
-F 0 "#PWR0236" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833DFE" Ref="#PWR0250"  Part="1"
+F 0 "#PWR0250" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E12" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E12" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833E12" Ref="#PWR0237"  Part="1"
-F 0 "#PWR0237" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833E12" Ref="#PWR0251"  Part="1"
+F 0 "#PWR0251" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833DD5" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833DD5" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A6/65833DD5" Ref="R115"  Part="1"
-F 0 "R115" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/657790A6/65833DD5" Ref="R93"  Part="1"
+F 0 "R93" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E27" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E27" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833E27" Ref="#PWR0230"  Part="1"
-F 0 "#PWR0230" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833E27" Ref="#PWR0244"  Part="1"
+F 0 "#PWR0244" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E35" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E35" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833E35" Ref="#PWR0233"  Part="1"
-F 0 "#PWR0233" H 4700 2600 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833E35" Ref="#PWR0247"  Part="1"
+F 0 "#PWR0247" H 4700 2600 50  0001 C CNN
 F 1 "GND" H 4705 2677 50  0000 C CNN
 F 2 "" H 4700 2850 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E43" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E43" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A6/65833E43" Ref="R116"  Part="1"
-F 0 "R116" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/657790A6/65833E43" Ref="R94"  Part="1"
+F 0 "R94" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/6386EF41" Ref="J?"  Part="1"
 AR Path="/6174477C/6577909A/6386EF41" Ref="J?"  Part="1"
-AR Path="/6174477C/657790A6/6386EF41" Ref="J23"  Part="1"
-F 0 "J23" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/657790A6/6386EF41" Ref="J27"  Part="1"
+F 0 "J27" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E58" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833E58" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833E58" Ref="#PWR0232"  Part="1"
-F 0 "#PWR0232" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833E58" Ref="#PWR0246"  Part="1"
+F 0 "#PWR0246" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E71" Ref="D?"  Part="1"
 AR Path="/6174477C/6577909A/65833E71" Ref="D?"  Part="1"
-AR Path="/6174477C/657790A6/65833E71" Ref="D22"  Part="1"
-F 0 "D22" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/657790A6/65833E71" Ref="D24"  Part="1"
+F 0 "D24" V 8439 2682 50  0000 R CNN
 F 1 "NODE14_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833E78" Ref="R?"  Part="1"
 AR Path="/6174477C/6577909A/65833E78" Ref="R?"  Part="1"
-AR Path="/6174477C/657790A6/65833E78" Ref="R117"  Part="1"
-F 0 "R117" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/657790A6/65833E78" Ref="R95"  Part="1"
+F 0 "R95" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/65833EF0" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/65833EF0" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/65833EF0" Ref="#PWR0238"  Part="1"
-F 0 "#PWR0238" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/657790A6/65833EF0" Ref="#PWR0252"  Part="1"
+F 0 "#PWR0252" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/6572958C/6379A741" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/6577909A/6379A741" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/657790A6/6379A741" Ref="#PWR0234"  Part="1"
-F 0 "#PWR0234" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/657790A6/6379A741" Ref="#PWR0248"  Part="1"
+F 0 "#PWR0248" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN
