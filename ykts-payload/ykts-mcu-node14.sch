File: ykts-payload/ykts-mcu-node14.sch (KiCad schematic (older format))
At the start: 12 parts, among them J22 AVR-ISP-6, SW15 ADG802BRT, U28 ATmega328PB-MU, Y17 8 MHz

Commit message: Revision A2
Added debug power
Basic ESD protection on UART
MCP Reset from MCU
Parts:
- renumbered D23 to D22, J22 to J23, R111 to R115, R112 to R116, R113 to R117
Changed lines of the file:
@@
 $Descr A4 11693 8268
 encoding utf-8
-Sheet 16 18
+Sheet 17 18
 Title "YktSat Payload Module"
-Date "2021-10-02"
-Rev "A1"
+Date "2021-10-03"
+Rev "A2"
 Comp "Sakha Aerospace Systems, LLC"
 Comment1 ""
@@
 AR Path="/6174477C/638385B8/63916C7E" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C7E" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C7E" Ref="#PWR0229"  Part="1"
-F 0 "#PWR0229" H 3500 2600 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C7E" Ref="#PWR0231"  Part="1"
+F 0 "#PWR0231" H 3500 2600 50  0001 C CNN
 F 1 "GND" H 3505 2677 50  0000 C CNN
 F 2 "" H 3500 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386EE34" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386EE34" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/6386EE34" Ref="#PWR0237"  Part="1"
-F 0 "#PWR0237" H 8400 4450 50  0001 C CNN
+AR Path="/6174477C/638DF127/6386EE34" Ref="#PWR0239"  Part="1"
+F 0 "#PWR0239" H 8400 4450 50  0001 C CNN
 F 1 "GND" H 8405 4527 50  0000 C CNN
 F 2 "" H 8400 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C82" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C82" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C82" Ref="#PWR0233"  Part="1"
-F 0 "#PWR0233" H 8000 4450 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C82" Ref="#PWR0235"  Part="1"
+F 0 "#PWR0235" H 8000 4450 50  0001 C CNN
 F 1 "GND" H 8005 4527 50  0000 C CNN
 F 2 "" H 8000 4700 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C8A" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C8A" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C8A" Ref="#PWR0234"  Part="1"
-F 0 "#PWR0234" H 8200 3950 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C8A" Ref="#PWR0236"  Part="1"
+F 0 "#PWR0236" H 8200 3950 50  0001 C CNN
 F 1 "GND" H 8205 4027 50  0000 C CNN
 F 2 "" H 8200 4200 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F141" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F141" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/6386F141" Ref="#PWR0235"  Part="1"
-F 0 "#PWR0235" H 8200 4150 50  0001 C CNN
+AR Path="/6174477C/638DF127/6386F141" Ref="#PWR0237"  Part="1"
+F 0 "#PWR0237" H 8200 4150 50  0001 C CNN
 F 1 "GND" H 8205 4227 50  0000 C CNN
 F 2 "" H 8200 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F147" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/6386F147" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF127/6386F147" Ref="R111"  Part="1"
-F 0 "R111" V 6754 4400 50  0000 C CNN
+AR Path="/6174477C/638DF127/6386F147" Ref="R115"  Part="1"
+F 0 "R115" V 6754 4400 50  0000 C CNN
 F 1 "20K" V 6845 4400 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 6950 4400 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F142" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F142" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/6386F142" Ref="#PWR0228"  Part="1"
-F 0 "#PWR0228" H 3500 1650 50  0001 C CNN
+AR Path="/6174477C/638DF127/6386F142" Ref="#PWR0230"  Part="1"
+F 0 "#PWR0230" H 3500 1650 50  0001 C CNN
 F 1 "+5V_A" H 3515 1973 50  0000 C CNN
 F 2 "" H 3500 1800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386F148" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/6386F148" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/6386F148" Ref="#PWR0231"  Part="1"
-F 0 "#PWR0231" H 4550 2600 50  0001 C CNN
+AR Path="/6174477C/638DF127/6386F148" Ref="#PWR0233"  Part="1"
+F 0 "#PWR0233" H 4550 2600 50  0001 C CNN
 F 1 "GND" H 4555 2677 50  0000 C CNN
 F 2 "" H 4550 2850 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C86" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/63916C86" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF127/63916C86" Ref="R112"  Part="1"
-F 0 "R112" V 8004 3950 50  0000 C CNN
+AR Path="/6174477C/638DF127/63916C86" Ref="R116"  Part="1"
+F 0 "R116" V 8004 3950 50  0000 C CNN
 F 1 "1M" V 8095 3950 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8200 3950 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C87" Ref="J?"  Part="1"
 AR Path="/6174477C/638385BA/63916C87" Ref="J?"  Part="1"
-AR Path="/6174477C/638DF127/63916C87" Ref="J22"  Part="1"
-F 0 "J22" H 3770 5146 50  0000 R CNN
+AR Path="/6174477C/638DF127/63916C87" Ref="J23"  Part="1"
+F 0 "J23" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
 F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C88" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C88" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C88" Ref="#PWR0230"  Part="1"
-F 0 "#PWR0230" H 4200 5300 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C88" Ref="#PWR0232"  Part="1"
+F 0 "#PWR0232" H 4200 5300 50  0001 C CNN
 F 1 "GND" H 4205 5377 50  0000 C CNN
 F 2 "" H 4200 5550 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C90" Ref="D?"  Part="1"
 AR Path="/6174477C/638385BA/63916C90" Ref="D?"  Part="1"
-AR Path="/6174477C/638DF127/63916C90" Ref="D23"  Part="1"
-F 0 "D23" V 8439 2682 50  0000 R CNN
+AR Path="/6174477C/638DF127/63916C90" Ref="D22"  Part="1"
+F 0 "D22" V 8439 2682 50  0000 R CNN
 F 1 "NODE14_STATUSLED" V 8348 2682 50  0000 R CNN
 F 2 "LED_SMD:LED_0402_1005Metric" H 8400 2800 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/6386EE40" Ref="R?"  Part="1"
 AR Path="/6174477C/638385BA/6386EE40" Ref="R?"  Part="1"
-AR Path="/6174477C/638DF127/6386EE40" Ref="R113"  Part="1"
-F 0 "R113" V 8204 3150 50  0000 C CNN
+AR Path="/6174477C/638DF127/6386EE40" Ref="R117"  Part="1"
+F 0 "R117" V 8204 3150 50  0000 C CNN
 F 1 "1K" V 8295 3150 50  0000 C CNN
 F 2 "Resistor_SMD:R_0402_1005Metric" H 8400 3150 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C84" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C84" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C84" Ref="#PWR0236"  Part="1"
-F 0 "#PWR0236" H 8400 3100 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C84" Ref="#PWR0238"  Part="1"
+F 0 "#PWR0238" H 8400 3100 50  0001 C CNN
 F 1 "GND" H 8405 3177 50  0000 C CNN
 F 2 "" H 8400 3350 50  0001 C CNN
@@
 AR Path="/6174477C/638385B8/63916C8D" Ref="#PWR?"  Part="1"
 AR Path="/6174477C/638385BA/63916C8D" Ref="#PWR?"  Part="1"
-AR Path="/6174477C/638DF127/63916C8D" Ref="#PWR0232"  Part="1"
-F 0 "#PWR0232" H 6100 5800 50  0001 C CNN
+AR Path="/6174477C/638DF127/63916C8D" Ref="#PWR0234"  Part="1"
+F 0 "#PWR0234" H 6100 5800 50  0001 C CNN
 F 1 "GND" H 6105 5877 50  0000 C CNN
 F 2 "" H 6100 6050 50  0001 C CNN

Commit message: Fix git
Connections:
- net +5V_A: no longer C84.1, C85.1, D22.2 (A), R115.2, U28.18 (AVCC), U28.20 (AREF), U28.4 (VCC)
- net at SW15.1 (D): now also C84.1, C85.1, D22.2 (A), R115.2, U28.18 (AVCC), U28.20 (AREF), U28.4 (VCC)

Commit message: Change node ISP connector footprint
Parts:
- J23: footprint Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical -> Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD
Changed lines of the file:
@@
 F 0 "J23" H 3770 5146 50  0000 R CNN
 F 1 "AVR-ISP-6" H 3770 5055 50  0000 R CNN
-F 2 "Connector_PinHeader_2.54mm:PinHeader_2x03_P2.54mm_Vertical" V 3850 5100 50  0001 C CNN
+F 2 "Connector_PinHeader_1.27mm:PinHeader_2x03_P1.27mm_Vertical_SMD" V 3850 5100 50  0001 C CNN
 F 3 " ~" H 2825 4500 50  0001 C CNN
 	1    4100 5050
