# Repository cansat-ptl/cubesat-boards (continued)

## KiCad design ykts-power/ykts-power.kicad_pcb

Board: 2 copper layers, 90.0 x 90.0 mm, 128 parts (0 on the bottom side), 84 nets.

Parts:
BT1, BT3: LIFEPO4; PinHeader_1x02_P2.54mm_Vertical
C1, C2, C22, C32: 22pF; C_0402_1005Metric
C3, C5, C6, C10, C11, C17, C24, C28: 100nF; C_0603_1608Metric
C4, C7, C35, C36: 22uF; CP_EIA-3216-10_Kemet-I
C8, C9, C12, C13, C14, C15, C23, C25, C26, C27, C29, C30: 10uF; C_0603_1608Metric
C16: 10nF; C_0402_1005Metric
C18: 10uF; CP_EIA-3216-10_Kemet-I
C19, C37: 0.1uF; C_0603_1608Metric
C20, C21, C31, C33, C34: 100nF; C_0402_1005Metric
D1: Generic; D_SOD-323
D2, D3, D4, D5: SS13; D_SMA
D6, D9, D10: G; LED_0603_1608Metric
D7, D8: SS23; D_SMB
J1: ICSP; PinHeader_2x03_P2.54mm_Horizontal
J2: B2_CHRG; PinHeader_1x02_P2.54mm_Horizontal
J3: B1_CHRG; PinHeader_1x02_P2.54mm_Horizontal
J4: GRD_PWR; PinHeader_1x03_P2.54mm_Horizontal
J5: Conn_02x20_Odd_Even_MountingPin; PinSocket_2x20_P2.54mm_Vertical
J6: PWR_HEAD; PinSocket_2x06_P2.54mm_Vertical
L1, L2, L3, L4: LPS4018-222MR; L_Coilcraft_LPS4018
L5: Ferrite; L_1206_3216Metric
Q1, Q2, Q3, Q4: KIA3415; SOT-23
R1, R2, R6, R7, R9, R11, R24, R27: 1K; R_0402_1005Metric
R3, R4, R5, R8, R10, R12, R20, R21: 10K; R_0402_1005Metric
R13, R14, R38, R41: 100; R_0603_1608Metric
R15, R17, R39, R42: NC; C_0402_1005Metric
R16, R18, R40, R43: NC; R_0603_1608Metric
R19, R22, R23: 0.1; R_2512_6332Metric
R25, R29: V; R_0402_1005Metric
R26, R30: 490K; R_0402_1005Metric
R28, R31: 100K; R_0402_1005Metric
R32, R33: V; R_0603_1608Metric
R34, R35, R36: 1K; R_0603_1608Metric
SC1: X+; PinHeader_1x02_P2.54mm_Vertical
SC2: X-; PinHeader_1x02_P2.54mm_Vertical
SC3: Y+; PinHeader_1x02_P2.54mm_Vertical
SC4: Y-; PinHeader_1x02_P2.54mm_Vertical
SW1: RBF; PinHeader_1x02_P2.54mm_Vertical
SW2: DEPLOY; PinHeader_1x02_P2.54mm_Vertical
U1: ATmega644A-AU; TQFP-44_10x10mm_P0.8mm
U2: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U3: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U4, U9: TPS63002; Texas_DRC0010J_ThermalVias
U5, U10: TPS63001; Texas_DRC0010J_ThermalVias
U6: INA3221AIRGVR; QFN-16-1EP_4x4mm_P0.65mm_EP2.1x2.1mm
U7, U14: BQ25070; WSON-10-1EP_2x3mm_P0.5mm_EP0.84x2.4mm
U8, U11, U12, U13: LM35-LP; TO-92
Y1: 8 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm
Y2: 12 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+3V3: C13.1, C15.1, C29.1, C30.1, J4.2, J6.10, R17.1, R22.2, R23.2, R36.1, R42.1, U5.1, U6.12, U6.15, U10.1
+3V3-A: J6.6, Q1.2, Q1.3, R5.1, R23.1, U6.11
+3V3-B: J6.4, Q2.2, Q2.3, R8.1, R22.1, U6.14
+5V: C3.1, C4.1, C6.1, C7.1, C12.1, C14.1, C16.1, C17.1, C18.1, C20.1, C21.1, C25.1, C26.1, C31.1, C33.1, C35.1, C36.1, D1.1, J4.1, J6.8, L5.1, R2.1, R3.2, R4.2, R15.1, R19.1, R25.1, R29.1, R35.1, R39.1, U1.5, U1.17, U1.30, U1.38, U2.20, U3.3, U3.5, U4.1, U6.2, U6.4, U8.1, U9.1, U11.1, U12.1, U13.1
+5V-A: J6.2, Q3.2, Q3.3, R10.1, R19.2, U6.1
+BATT: C8.1, C9.1, C23.1, C27.1, D7.1, D8.1, Q4.2, R12.1, R13.1, R14.1, R38.1, R41.1, SW1.1, SW2.2, U1.32, U4.5, U5.5, U9.5, U10.5
/ICSP_MISO: J1.1, U1.2, U2.17
/ICSP_MOSI: J1.4, U1.1, U2.16
/ICSP_RESET: J1.5, U1.4
/ICSP_SCK: J1.3, U1.3, U2.14
/MCU_3V3A: R6.2, U1.16
/MCU_3V3B: R7.2, U1.15
/MCU_5VA: R9.2, U1.14
/MCU_BHEAT: R11.2, U1.13
/MCU_BPROBE01: U1.37, U8.2
/MCU_BPROBE02: U1.36, U11.2
/MCU_BPROBE11: U1.35, U12.2
/MCU_BPROBE12: U1.34, U13.2
/MCU_BQCTRL0: U1.40, U7.7
/MCU_BQCTRL1: U1.41, U14.7
/MCU_BQSTAT0: R25.2, U1.25, U7.8
/MCU_BQSTAT1: R29.2, U1.26, U14.8
/MCU_VSOL: R32.2, R33.1, U1.33
/PWR_CANBUS/MCP_!CS: U1.43, U2.18
/PWR_CANBUS/MCP_!INT: U1.42, U2.13
/PWR_CHARGER/BQ0_OUT: BT1.1, D7.2, J3.2, U7.6, U7.10
/PWR_CHARGER/BQ1_OUT: BT3.1, D8.2, J2.2, U14.6, U14.10
/PWR_CSENSOR/INA_CRIT: U1.21, U6.9
/PWR_CSENSOR/INA_SCL: R3.1, U1.19, U6.6
/PWR_CSENSOR/INA_SDA: R4.1, U1.20, U6.7
/PWR_CSENSOR/INA_TCTRL: U1.23, U6.13
/PWR_CSENSOR/INA_WARN: U1.22, U6.8
/PWR_CSENSOR/PV: R21.2, U6.10
BAT_HEAT: J6.12, Q4.3
CANH: J5.4, U3.7
CANL: J5.6, U3.6
GND: BT1.2, BT3.2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, D6.1, D9.1, D10.1, J1.6, J2.1, J3.1, J4.3, J5.1, J5.2, J5.3, J5.5, J5.7, J5.8, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, R16.2, R18.2, R20.2, R24.2, R27.2, R28.2, R31.2, R33.2, R40.2, R43.2, SC1.2, SC2.2, SC3.2, SC4.2, U1.6, U1.18, U1.28, U1.39, U2.10, U3.2, U3.8, U4.3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
unnamed: C1.1, U2.8, Y2.3
unnamed: C2.1, U2.9, Y2.1
unnamed: C5.1, D1.2, R1.1, R2.2
unnamed: C10.1, R13.2, U4.6, U4.7, U4.8
unnamed: C11.1, R14.2, U5.6, U5.7, U5.8
unnamed: C22.1, U1.8, Y1.1
unnamed: C24.1, R38.2, U9.6, U9.7, U9.8
unnamed: C28.1, R41.2, U10.6, U10.7, U10.8
unnamed: C32.1, U1.7, Y1.3
unnamed: C34.1, L5.2, U1.27
unnamed: D2.2, SC1.1
unnamed: D3.2, SC2.1
unnamed: D4.2, SC3.1
unnamed: D5.2, SC4.1
unnamed: D6.2, R34.2
unnamed: D9.2, R35.2
unnamed: D10.2, R36.2
unnamed: L1.1, U4.4
unnamed: L1.2, U4.2
unnamed: L2.1, U5.4
unnamed: L2.2, U5.2
unnamed: L3.1, U9.4
unnamed: L3.2, U9.2
unnamed: L4.1, U10.4
unnamed: L4.2, U10.2
unnamed: Q1.1, R5.2, R6.1
unnamed: Q2.1, R7.1, R8.2
unnamed: Q3.1, R9.1, R10.2
unnamed: Q4.1, R11.1, R12.2
unnamed: R1.2, U2.19
unnamed: R15.2, R16.1, U4.10
unnamed: R17.2, R18.1, U5.10
unnamed: R20.1, U6.5
unnamed: R21.1, U6.16
unnamed: R24.1, U7.2
unnamed: R26.1, U7.4
unnamed: R26.2, R28.1, U7.5
unnamed: R27.1, U14.2
unnamed: R30.1, U14.4
unnamed: R30.2, R31.1, U14.5
unnamed: R39.2, R40.1, U9.10
unnamed: R42.2, R43.1, U10.10
unnamed: SW1.2, SW2.1
unnamed: U2.1, U3.4
unnamed: U2.2, U3.1
PW_OK: J5.10, R34.1, U1.12
VSOLAR: C19.1, C37.1, D2.1, D3.1, D4.1, D5.1, R32.1, U7.1, U14.1

## Commit log

2020-03-30 Initial upload
2020-03-31 Broke everything
2021-09-20 Project init
2021-09-30 First sheet complete
2021-09-30 Sync changes
2021-10-01 Add nodes
2021-10-01 Update nodes
2021-10-02 Schematic mostly complete
2021-10-02 Revision A0
2021-10-02 Fixed annotations & sheet ordering
2021-10-03 Revision A2
    Added debug power
    Basic ESD protection on UART
    MCP Reset from MCU
2021-10-03 Revision A3
    Fixed node power switch connection
2021-10-03 Fix git
2021-10-05 Change node ISP connector footprint
2021-10-08 Update PCB
2021-10-08 PC/104 Outline
2021-10-22 Revision B0
    Added second supervisor, mega2560 -> mega128a
2021-10-26 Revision B2
    Hierarchal sheets for nodes
    Partial PCB layout
2021-10-29 Revision C0
    Basic OC protection on 5V_A & 5V_B
    SD Card -> SPI Flash
    MCU Node boards
2021-10-29 Fix node power
2021-10-31 Merge with github repo
    Update naming scheme for older boards
    Prepare for merge
2021-11-01 Revision C1
    Added CH_A & CH_B power control switches
2021-11-26 Hierarchal sheet rework
2021-12-01 Revision D0
2021-12-03 Bump
2021-12-06 Bump board
2021-12-06 Fix DRC on payload
2021-12-06 Rework power supply
2021-12-07 Revision D1, board A0
    Board initial release
2021-12-07 Remove large step file
2021-12-08 Fix RXCAN and TXCAN connection
2021-12-18 Bump version
2021-12-21 Board revision A2
    Ready for production
    Added geigerboard
2022-01-28 Board revision A3, Schematic D3
    Added 5V LDO (Fixed #15)
    Added decoupling caps for mounting holes (Fixed #12)
    More space for flash LDO (Fixed #1)
    Removed TVS diodes from CAN bus (Fixed #3)
2022-01-28 Changed flash LDO to L78L33
2022-01-28 Gerbers for rev A3
    Minor fixes
2022-01-29 Revision A4-Hotfix
    Fixed incorrect package for supervisor flash
2022-02-07 Board revision A5, schematic E0
    Fixed #16
    Fixed #17
    Revamped schematic
2022-02-07 Schematic revision E1
    Cleanup
2022-02-07 SiPM analog detector schematic
2022-02-14 MCU Node silkscreen improvements
    Fixes #7
2022-06-21 Sync with remote
