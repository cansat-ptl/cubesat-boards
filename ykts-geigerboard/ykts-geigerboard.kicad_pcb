# Repository cansat-ptl/cubesat-boards

## KiCad design ykts-geigerboard/ykts-geigerboard.kicad_pcb

Board: 2 copper layers, 59.8 x 52.5 mm, 29 parts (11 on the bottom side), 9 nets, no tracks yet.

Parts:
C1: 1uF; C_0603_1608Metric
C2: 100nF; C_0402_1005Metric
C3, C4: 22pF; C_0402_1005Metric
D1: NODE_STATUSLED; LED_0402_1005Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad
J1: Conn_01x07_Female; PinSocket_1x07_P1.27mm_Vertical
J2, J3, J6, J6#2, J6#3, J6#4: Conn_01x05_Female; Molex_PicoBlade_53048-0510_1x05_P1.25mm_Horizontal
Q1, Q2: RJU003N03 NMOS; SOT-323_SC-70
R1: 20K; R_0402_1005Metric
R2, R3: 10K; R_0402_1005Metric
R4: 1K; R_0402_1005Metric
SW1: ADG802BRT; SOT-23-6
U1: ATmega328PB-MU; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U2: LMV7239M5; SOT-23-5
U3: TS5A3166DBVR; SOT-23-5
U4: AD8606ARZ; SOIC-8_3.9x4.9mm_P1.27mm
U5: LMC555xM; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, SW1.2 (S), SW1.6 (VDD)
/ISP_RESET: R1.1, U1.29 (~RESET/PC6)
GND: C1.2, C2.2, C3.2, C4.2, R4.1, SW1.3 (GND), U1.5 (GND), U1.21 (GND), U1.33 (GND), Y1.2, Y1.4
unnamed: C2.1, D1.2 (A), Q1.2 (G), Q2.2 (G), R1.2, R2.2, R3.2, SW1.1 (D), U1.4 (VCC), U1.18 (AVCC), U1.20 (AREF)
unnamed: C3.1, U1.8 (XTAL2/PB7), Y1.3
unnamed: C4.1, U1.7 (XTAL1/PB6), Y1.1
unnamed: D1.1 (K), R4.2
unnamed: Q1.1 (S), R2.1, U1.27 (PC4)
unnamed: Q2.1 (S), R3.1, U1.28 (PC5)

## KiCad design ykts-payload/ykts-payload.kicad_pcb

Board: 4 copper layers, 95.9 x 90.2 mm, 154 parts (60 on the bottom side), 165 nets.

Parts:
C1, C2, C10, C11, C16, C17, C25, C26: 22pF; C_0402_1005Metric
C3, C4, C5, C9, C12, C14, C15, C18, C19, C20, C27, C29, C30, C36: 100nF; C_0402_1005Metric
C6, C21: 22uF; C_0805_2012Metric
C7, C22: 10uF; C_0603_1608Metric
C8, C23: 22uF; C_0603_1608Metric
C13, C28, C34: 1uF; C_0603_1608Metric
C24, C31, C32, C33: 10nF 1000V; C_0603_1608Metric
CH1, CH2, CH3, CH4: 50pF; C_0402_1005Metric
CL1, CL2, CL3, CL4: 50pF; C_0402_1005Metric
D2, D6: LED_STATUS; LED_0402_1005Metric
D3: LED; LED_0402_1005Metric
FL1, FL2: DLW21SN921SK2; L_CommonModeChoke_Coilcraft_0805USB
H1, H2, H3, H4: Chasis / M3; MountingHole_3.2mm_M3_ISO7380_Pad
H5, H6, H7, H8, H9: Geiger / M2; MountingHole_2.2mm_M2_Pad
J1: DBG_PWR; PinHeader_1x03_P2.54mm_Vertical
J2: GeigerBoard; PinHeader_1x07_P1.27mm_Vertical
J3: Conn_02x32_Odd_Even; PinHeader_2x32_P2.54mm_Vertical
J4: Solar_Temp; PinHeader_1x03_P1.27mm_Vertical
J5: Sensor_Ext; PinHeader_1x04_P1.27mm_Vertical
J6, J8: AVR ISP; PinHeader_2x03_P1.27mm_Vertical_SMD
J7, J9: DBG_UART; PinHeader_1x03_P2.54mm_Vertical
L1, L2: Ferrite; L_1206_3216Metric
N1, N2, N3, N4, N5, N6, N7, N8, N9, N10, N11, N12, N13, N14, N15, N16: YKTS-MCU-NODE; YktSat_MCU_node
Q1: PMV65XP; SOT-23
R1, R2, R3, R4: 10M; R_0603_1608Metric
R5, R24, R25, R43: 0; R_0402_1005Metric
R6, R7: 30K; R_0402_1005Metric
R8, R20, R21, R22, R40, R41, R42: 4.7K; R_0402_1005Metric
R9, R13, R14, R15, R16, R23, R29, R33, R34, R35, R36, R47: 1K; R_0402_1005Metric
R10, R17, R18, R19, R30, R37, R38, R39, R48: 10K; R_0402_1005Metric
R11, R31: 20K; R_0402_1005Metric
R12, R28, R32, R46: 1M; R_0402_1005Metric
R26, R27, R44, R45: 33K; R_0402_1005Metric
R_CSB1: 0.1; R_1210_3225Metric
U1, U9: ATmega128A-AU; TQFP-64_14x14mm_P0.8mm
U2, U10: L78L33_SOT89; SOT-89-3
U3, U11: AT25DF161-SF-T; SO-8_5.3x6.2mm_P1.27mm
U4: MAX4372FEUK; SOT-23-5
U5, U6, U15, U16: 74HC4051BQ,115; TSSOP-16_4.4x5mm_P0.65mm
U7, U13: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U8, U14: MCP2551-I-SN; SOIC-8_3.9x4.9mm_P1.27mm
U12: AMS1117-5.0; SOT-223-3_TabPin2
Y1, Y3: 8 MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm
Y2, Y4: 12MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C3.1, C4.1, C6.1, C7.1, C9.1, C12.1, C13.1, C15.1, C18.1, C19.1, C21.1, C22.1, C27.1, C28.1, C30.1, D3.2 (A), J1.2, J4.2, J5.1, L1.1, L2.1, N1.7 (VCC), N2.7 (VCC), N3.7 (VCC), N4.7 (VCC), N5.7 (VCC), N6.7 (VCC), N7.7 (VCC), N8.7 (VCC), N9.7 (VCC), N10.7 (VCC), N11.7 (VCC), N12.7 (VCC), N13.7 (VCC), N14.7 (VCC), N15.7 (VCC), N16.7 (VCC), Q1.3 (S), R6.1, R7.2, R8.1, R10.1, R11.2, R26.1, R27.2, R30.1, R31.2, R44.1, R45.2, R48.1, R_CSB1.1, U1.21 (VCC), U1.52 (VCC), U2.3 (IN), U4.3 (VCC), U4.5 (RS-), U5.7 (VEE), U5.16 (VCC), U6.7 (VEE), U6.16 (VCC), U7.20 (VDD), U8.3 (VDD), U8.5 (Vref), U9.21 (VCC), U9.52 (VCC), U10.3 (IN), U13.20 (VDD), U14.3 (VDD), U14.5 (Vref), U15.7 (VEE), U15.16 (VCC), U16.7 (VEE), U16.16 (VCC)
+5V_GEIGER: J2.4, Q1.2 (D)
/1WIRE: J4.3, R8.2, U1.32 (PD7), U9.32 (PD7)
/CANBUS Controller 0/CS: U1.14 (PB4), U7.18 (~CS)
/CANBUS Controller 0/MCP_INT: U1.6 (PE4), U7.13 (~INT)
/CANBUS Controller 0/MCP_RESET: C14.1, R29.1, R30.2, U1.17 (PB7)
/CANBUS Controller 0/MCP_RX0BF: U1.7 (PE5), U7.12 (~RX0BF)
/CANBUS Controller 0/MCP_RX1BF: U1.8 (PE6), U7.11 (~RX1BF)
/CANBUS Controller 0/MCP_TX0RTS: U1.9 (PE7), U7.4 (~TX0RTS)
/CANBUS Controller 0/MISO: J6.1, U1.13 (PB3), U3.2 (SO/IO1), U7.17 (SO)
/CANBUS Controller 0/MOSI: J6.4, R21.2, U1.12 (PB2), U7.16 (SI)
/CANBUS Controller 0/SCK: J6.3, R20.2, U1.11 (PB1), U7.14 (SCK)
/CANBUS Controller 1/CS: U9.14 (PB4), U13.18 (~CS)
/CANBUS Controller 1/MCP_INT: U9.6 (PE4), U13.13 (~INT)
/CANBUS Controller 1/MCP_RESET: C29.1, R47.1, R48.2, U9.17 (PB7)
/CANBUS Controller 1/MCP_RX0BF: U9.7 (PE5), U13.12 (~RX0BF)
/CANBUS Controller 1/MCP_RX1BF: U9.8 (PE6), U13.11 (~RX1BF)
/CANBUS Controller 1/MCP_TX0RTS: U9.9 (PE7), U13.4 (~TX0RTS)
/CANBUS Controller 1/MISO: J8.1, U9.13 (PB3), U11.2 (SO/IO1), U13.17 (SO)
/CANBUS Controller 1/MOSI: J8.4, R41.2, U9.12 (PB2), U13.16 (SI)
/CANBUS Controller 1/SCK: J8.3, R40.2, U9.11 (PB1), U13.14 (SCK)
/CSENSE: U1.61 (PF0), U4.2 (OUT), U9.61 (PF0)
/GEIGER_EN: J2.5, R13.2, R33.2
/GEIGER_FET: R9.2, U1.19 (PG4), U9.19 (PG4)
/N0_PWR: N1.1 (PWEN), U1.40 (PC5)
/N0_RST: N1.2 (~RST), U1.39 (PC4)
/N0_RX: N1.3 (RX), U6.13 (A0)
/N0_TX: N1.4 (TX), U5.13 (A0)
/N1_PWR: N2.1 (PWEN), U1.41 (PC6)
/N1_RST: N2.2 (~RST), U1.42 (PC7)
/N1_RX: N2.3 (RX), U6.12 (A3)
/N1_TX: N2.4 (TX), U5.12 (A3)
/N2_PWR: N3.1 (PWEN), U1.45 (PA6)
/N2_RST: N3.2 (~RST), U1.44 (PA7)
/N2_RX: N3.3 (RX), U6.5 (A5)
/N2_TX: N3.4 (TX), U5.5 (A5)
/N3_PWR: N4.1 (PWEN), U1.47 (PA4)
/N3_RST: N4.2 (~RST), U1.46 (PA5)
/N3_RX: N4.3 (RX), U6.4 (A7)
/N3_TX: N4.4 (TX), U5.4 (A7)
/N4_PWR: N5.1 (PWEN), U1.35 (PC0)
/N4_RST: N5.2 (~RST), U1.36 (PC1)
/N4_RX: N5.3 (RX), U6.14 (A1)
/N4_TX: N5.4 (TX), U5.14 (A1)
/N5_PWR: N6.1 (PWEN), U1.50 (PA1)
/N5_RST: N6.2 (~RST), U1.51 (PA0)
/N5_RX: N6.3 (RX), U6.2 (A6)
/N5_TX: N6.4 (TX), U5.2 (A6)
/N6_PWR: N7.1 (PWEN), U1.37 (PC2)
/N6_RST: N7.2 (~RST), U1.38 (PC3)
/N6_RX: N7.3 (RX), U6.15 (A2)
/N6_TX: N7.4 (TX), U5.15 (A2)
/N7_PWR: N8.1 (PWEN), U1.48 (PA3)
/N7_RST: N8.2 (~RST), U1.49 (PA2)
/N7_RX: N8.3 (RX), U6.1 (A4)
/N7_TX: N8.4 (TX), U5.1 (A4)
/N8_PWR: N9.1 (PWEN), U9.37 (PC2)
/N8_RST: N9.2 (~RST), U9.38 (PC3)
/N8_RX: N9.3 (RX), U16.14 (A1)
/N8_TX: N9.4 (TX), U15.14 (A1)
/N9_PWR: N10.1 (PWEN), U9.35 (PC0)
/N9_RST: N10.2 (~RST), U9.36 (PC1)
/N9_RX: N10.3 (RX), U16.12 (A3)
/N9_TX: N10.4 (TX), U15.12 (A3)
/N10_PWR: N11.1 (PWEN), U9.41 (PC6)
/N10_RST: N11.2 (~RST), U9.42 (PC7)
/N10_RX: N11.3 (RX), U16.5 (A5)
/N10_TX: N11.4 (TX), U15.5 (A5)
/N11_PWR: N12.1 (PWEN), U9.45 (PA6)
/N11_RST: N12.2 (~RST), U9.44 (PA7)
/N11_RX: N12.3 (RX), U16.4 (A7)
/N11_TX: N12.4 (TX), U15.4 (A7)
/N12_PWR: N13.1 (PWEN), U9.47 (PA4)
/N12_RST: N13.2 (~RST), U9.46 (PA5)
/N12_RX: N13.3 (RX), U16.15 (A2)
/N12_TX: N13.4 (TX), U15.15 (A2)
/N13_PWR: N14.1 (PWEN), U9.50 (PA1)
/N13_RST: N14.2 (~RST), U9.51 (PA0)
/N13_RX: N14.3 (RX), U16.2 (A6)
/N13_TX: N14.4 (TX), U15.2 (A6)
/N14_PWR: N15.1 (PWEN), U9.40 (PC5)
/N14_RST: N15.2 (~RST), U9.39 (PC4)
/N14_RX: N15.3 (RX), U16.13 (A0)
/N14_TX: N15.4 (TX), U15.13 (A0)
/N15_PWR: N16.1 (PWEN), U9.48 (PA3)
/N15_RST: N16.2 (~RST), U9.49 (PA2)
/N15_RX: N16.3 (RX), U16.1 (A4)
/N15_TX: N16.4 (TX), U15.1 (A4)
/PCH4: C34.1, J3.17, J3.18, U12.3 (VI)
/Payload Supervisor 0/MUX_A0: U1.31 (PD6), U5.11 (S0), U6.11 (S0)
/Payload Supervisor 0/MUX_A1: U1.30 (PD5), U5.10 (S1), U6.10 (S1)
/Payload Supervisor 0/MUX_A2: U1.29 (PD4), U5.9 (S2), U6.9 (S2)
/Payload Supervisor 0/RX1: U1.27 (PD2), U5.3 (A)
/Payload Supervisor 0/SD_CS: R22.2, U1.15 (PB5)
/Payload Supervisor 0/TX1: U1.28 (PD3), U6.3 (A)
/Payload Supervisor 1/MUX_A0: U9.31 (PD6), U15.9 (S2), U16.9 (S2)
/Payload Supervisor 1/MUX_A1: U9.30 (PD5), U15.10 (S1), U16.10 (S1)
/Payload Supervisor 1/MUX_A2: U9.29 (PD4), U15.11 (S0), U16.11 (S0)
/Payload Supervisor 1/RX1: U9.27 (PD2), U15.3 (A)
/Payload Supervisor 1/SD_CS: R42.2, U9.15 (PB5)
/Payload Supervisor 1/TX1: U9.28 (PD3), U16.3 (A)
/SCL: J2.6, J5.2, N1.6 (SCL), N2.6 (SCL), N3.6 (SCL), N4.6 (SCL), N5.6 (SCL), N6.6 (SCL), N7.6 (SCL), N8.6 (SCL), N9.6 (SCL), N10.6 (SCL), N11.6 (SCL), N12.6 (SCL), N13.6 (SCL), N14.6 (SCL), N15.6 (SCL), N16.6 (SCL), R7.1, U1.25 (PD0), U9.25 (PD0)
/SDA: J2.2, J5.4, N1.5 (SDA), N2.5 (SDA), N3.5 (SDA), N4.5 (SDA), N5.5 (SDA), N6.5 (SDA), N7.5 (SDA), N8.5 (SDA), N9.5 (SDA), N10.5 (SDA), N11.5 (SDA), N12.5 (SDA), N13.5 (SDA), N14.5 (SDA), N15.5 (SDA), N16.5 (SDA), R6.2, U1.26 (PD1), U9.26 (PD1)
CANH: CH2.1, CH4.1, FL1.2, FL2.2, J3.26
CANL: CL2.1, CL4.1, FL1.4, FL2.4, J3.25
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.1, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C34.2, C36.2, CH1.2, CH2.2, CH3.2, CH4.2, CL1.2, CL2.2, CL3.2, CL4.2, H5.1, H6.1, H7.1, H8.1, H9.1, J1.1, J1.3, J2.1, J2.7, J3.19, J3.20, J4.1, J5.3, J6.6, J7.2, J8.6, J9.2, N1.8 (GND), N2.8 (GND), N3.8 (GND), N4.8 (GND), N5.8 (GND), N6.8 (GND), N7.8 (GND), N8.8 (GND), N9.8 (GND), N10.8 (GND), N11.8 (GND), N12.8 (GND), N13.8 (GND), N14.8 (GND), N15.8 (GND), N16.8 (GND), R1.2, R2.2, R3.2, R4.2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
unnamed: C1.1, R12.1, U1.24 (XTAL1), Y1.1
unnamed: C2.1, R12.2, U1.23 (XTAL2), Y1.3
unnamed: C5.1, L1.2, U1.64 (AVCC)
unnamed: C8.1, U2.1 (OUT), U3.3 (~WP), U3.7 (~HOLD), U3.8 (VCC)
unnamed: C10.1, R28.2, U7.8 (OSC2), Y2.3
unnamed: C11.1, R28.1, U7.9 (OSC1), Y2.1
unnamed: C16.1, R32.1, U9.24 (XTAL1), Y3.1
unnamed: C17.1, R32.2, U9.23 (XTAL2), Y3.3
unnamed: C20.1, L2.2, U9.64 (AVCC)
unnamed: C23.1, U10.1 (OUT), U11.3 (~WP), U11.7 (~HOLD), U11.8 (VCC)
unnamed: C24.2, H1.1, R1.1
unnamed: C25.1, R46.2, U13.8 (OSC2), Y4.3
unnamed: C26.1, R46.1, U13.9 (OSC1), Y4.1
unnamed: C31.2, H2.1, R2.1
unnamed: C32.2, H3.1, R3.1
unnamed: C33.2, H4.1, R4.1
unnamed: C36.1, R_CSB1.2, U4.4 (RS+), U12.2 (VO)
unnamed: CH1.1, FL1.1, U8.7 (CANH)
unnamed: CH3.1, FL2.1, U14.7 (CANH)
unnamed: CL1.1, FL1.3, U8.6 (CANL)
unnamed: CL3.1, FL2.3, U14.6 (CANL)
unnamed: D2.1 (K), R16.2
unnamed: D2.2 (A), U1.16 (PB6)
unnamed: D3.1 (K), R23.1
unnamed: D6.1 (K), R36.2
unnamed: D6.2 (A), U9.16 (PB6)
unnamed: J6.5, R11.1, U1.20 (~RESET)
unnamed: J7.1, R15.2
unnamed: J7.3, R14.1
unnamed: J8.5, R31.1, U9.20 (~RESET)
unnamed: J9.1, R35.2
unnamed: J9.3, R34.1
unnamed: Q1.1 (G), R9.1, R10.2
unnamed: R5.1, U7.1 (TXCAN)
unnamed: R5.2, U8.1 (TXD)
unnamed: R13.1, U1.18 (PG3)
unnamed: R14.2, U1.2 (PE0)
unnamed: R15.1, U1.3 (PE1)
unnamed: R17.1, R20.1, U3.6 (SCK)
unnamed: R18.1, R21.1, U3.5 (SI/IO0)
unnamed: R19.1, R22.1, U3.1 (~CS)
unnamed: R24.1, U8.4 (RXD)
unnamed: R24.2, U7.2 (RXCAN)
unnamed: R25.1, U13.1 (TXCAN)
unnamed: R25.2, U14.1 (TXD)
unnamed: R26.2, U5.6 (~E)
unnamed: R27.1, U6.6 (~E)
unnamed: R29.2, U7.19 (~RESET)
unnamed: R33.1, U9.18 (PG3)
unnamed: R34.2, U9.2 (PE0)
unnamed: R35.1, U9.3 (PE1)
unnamed: R37.1, R40.1, U11.6 (SCK)
unnamed: R38.1, R41.1, U11.5 (SI/IO0)
unnamed: R39.1, R42.1, U11.1 (~CS)
unnamed: R43.1, U14.4 (RXD)
unnamed: R43.2, U13.2 (RXCAN)
unnamed: R44.2, U15.6 (~E)
unnamed: R45.1, U16.6 (~E)
unnamed: R47.2, U13.19 (~RESET)

## KiCad design cubesat-brdtemplate/cubesat-board.kicad_pcb

Board: 2 copper layers, 90.0 x 90.0 mm, 28 parts (0 on the bottom side), 19 nets.

Parts:
C1, C2, C22, C32: 22pF; C_0402_1005Metric
C3, C5, C6: 100nF; C_0603_1608Metric
C4, C7, C35, C36: 22uF; CP_EIA-3216-10_Kemet-I
C20, C21, C31, C33, C34: 100nF; C_0402_1005Metric
D1: Generic; D_SOD-323
J1: ICSP; PinHeader_2x03_P2.54mm_Horizontal
J5: Conn_02x20_Odd_Even_MountingPin; PinSocket_2x20_P2.54mm_Vertical
J6: PWR_HEAD; PinSocket_2x06_P2.54mm_Vertical
L5: Ferrite; L_1206_3216Metric
R1, R2: 1K; R_0402_1005Metric
U1: ATmega644A-AU; TQFP-44_10x10mm_P0.8mm
U2: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U3: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm
Y2: 12 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+5V: C3.1, C4.1, C6.1, C7.1, C20.1, C21.1, C31.1, C33.1, C35.1, C36.1, D1.1, J6.8, L5.1, R2.1, U1.5, U1.17, U1.38, U2.20, U3.3, U3.5
/ICSP_MISO: J1.1, U1.2, U2.17
/ICSP_MOSI: J1.4, U1.1, U2.16
/ICSP_RESET: J1.5, U1.4
/ICSP_SCK: J1.3, U1.3, U2.14
/PWR_CANBUS/MCP_!CS: U1.42, U2.18
/PWR_CANBUS/MCP_!INT: U1.43, U2.13
CANH: J5.4, U3.7
CANL: J5.6, U3.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C20.2, C21.2, C22.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, J1.6, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, U1.6, U1.18, U1.28, U1.39, U2.10, U3.2, U3.8, Y1.2, Y1.4, Y2.2, Y2.4
unnamed: C1.1, U2.8, Y2.3
unnamed: C2.1, U2.9, Y2.1
unnamed: C5.1, D1.2, R1.1, R2.2
unnamed: C22.1, U1.8, Y1.1
unnamed: C32.1, U1.7, Y1.3
unnamed: C34.1, L5.2, U1.27
unnamed: R1.2, U2.19
unnamed: U2.1, U3.4
unnamed: U2.2, U3.1

## KiCad design cubesat-fcu/cubesat-fcu.kicad_pcb

Board: 2 copper layers, 90.0 x 90.0 mm, 22 parts (0 on the bottom side), 45 nets.

Parts:
C1, C2: 22pF; C_0402_1005Metric
C3, C5, C6: 100nF; C_0603_1608Metric
C4, C7: 22uF; CP_EIA-3216-10_Kemet-I
C9, C10: 100nF; C_0402_1005Metric
D1: Generic; D_SOD-323
J1: ICSP; PinHeader_2x03_P2.54mm_Horizontal
J5: Conn_02x20_Odd_Even_MountingPin; PinSocket_2x20_P2.54mm_Vertical
J6: PWR_HEAD; PinSocket_2x06_P2.54mm_Vertical
R1, R2: 1K; R_0402_1005Metric
U1: ATxmega128A1U-AU; TQFP-100_14x14mm_P0.5mm
U2: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U3: TJA1051T-3; SOIC-8_3.9x4.9mm_P1.27mm
U4, U5: 74HC573#SOIC; TSSOP-20_4.4x6.5mm_P0.65mm
U6: IS61C5128AL-10TLI; TSOP-II-44_10.16x18.41mm_P0.8mm
Y2: 12 MHz; Crystal_SMD_5032-4Pin_5.0x3.2mm

Connections:
+3V3-A: C3.1, C4.1, C9.1, C10.1, D1.1, J6.6, R2.1, U2.20, U3.5, U4.20, U5.20, U6.11, U6.33
+5V-A: C6.1, C7.1, J6.2, U3.3
/FCU_MEMORY/FCU_ALE1: U1.57, U4.11
/FCU_MEMORY/FCU_ALE2: U1.58, U5.11
/FCU_MEMORY/FCU_MEM_~OE: U1.56, U6.37
/FCU_MEMORY/FCU_MEM_~WE: U1.55, U6.15
/PJ0: U1.65, U6.9
/PJ1: U1.66, U6.10
/PJ2: U1.67, U6.13
/PJ3: U1.68, U6.14
/PJ4: U1.69, U6.31
/PJ5: U1.70, U6.32
/PJ6: U1.71, U6.35
/PJ7: U1.72, U6.36
/PK0: U1.75, U4.2, U5.2, U6.3
/PK1: U1.76, U4.3, U5.3, U6.4
/PK2: U1.77, U4.4, U5.4, U6.5
/PK3: U1.78, U4.5, U6.6
/PK4: U1.79, U4.6, U6.7
/PK5: U1.80, U4.7, U6.16
/PK6: U1.81, U4.8, U6.17
/PK7: U1.82, U4.9, U6.18
CANH: J5.4, U3.7
CANL: J5.6, U3.6
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, J1.6, J5.1, J5.2, J5.3, J5.5, J5.7, J5.8, J6.1, J6.3, J6.5, J6.7, J6.9, J6.11, U2.10, U3.2, U3.8, U4.1, U4.10, U5.1, U5.10, U6.8, U6.12, U6.34, Y2.2, Y2.4
unnamed: C1.1, U2.8, Y2.3
unnamed: C2.1, U2.9, Y2.1
unnamed: C5.1, D1.2, R1.1, R2.2
unnamed: R1.2, U2.19
unnamed: U1.4, U1.94
unnamed: U1.3, U1.13, U1.23, U1.33, U1.43, U1.53, U1.63, U1.73, U1.84, U1.93
unnamed: U1.14, U1.24, U1.34, U1.44, U1.54, U1.64, U1.74, U1.83
unnamed: U2.1, U3.4
unnamed: U2.2, U3.1
unnamed: U4.12, U6.38
unnamed: U4.13, U6.30
unnamed: U4.14, U6.29
unnamed: U4.15, U6.28
unnamed: U4.16, U6.27
unnamed: U4.17, U6.26
unnamed: U4.18, U6.20
unnamed: U4.19, U6.19
unnamed: U5.17, U6.41
unnamed: U5.18, U6.40
unnamed: U5.19, U6.39
